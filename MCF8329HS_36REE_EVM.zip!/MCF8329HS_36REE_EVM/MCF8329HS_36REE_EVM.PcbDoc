# Altium PCB MCF8329HS_36REE_EVM.PcbDoc (part 2 of 3)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 3650 x 4750 mil, 4 copper layers (Top Layer, GND Layer, Power Layer, Bottom Layer), stack 58.4 mil thick; 243 components, 121 nets, 619 pads, 914 vias.

## Part data (continued)
J9: library part CMP-0075429-1, "Header, 100mil, 16x2, Gold, TH", Color=Black, Current_A=6.3A, Manufacturer=Samtec, Supplier Part Number 1=SAM1028-16-ND, Voltage_V=550V
J10: library part CMP-0121275-2, "2 Position Wire to Board Terminal Block Horizontal with Board 0.375\" (9.53mm) Through Hole", Current_A=24A, Digikey Part Number=732-691250910002-ND, Manufacturer="Wurth Electronics", Mouser Part Number=710-691250910002, Operating Temperature Range="-30°C to +120°C", Voltage_V=300V
J11: library part CMP-0121276-2, "3 Position Wire to Board Terminal Block Horizontal with Board 0.375\" (9.53mm) Through Hole", Current_A=24A, Digikey Part Number=732-691250910003-ND, Manufacturer="Wurth Electronics", Mouser Part Number=710-691250910003, Operating Temperature Range="-30°C to +120°C", Voltage_V=300V
J12: library part CMP-0054802-2, "Header, 2.54mm, 3x2, Gold, TH", Color=Black, Manufacturer="Wurth Elektronik", Supplier Part Number 1=732-5295-ND
J13: library part CMP-0054802-2, "Header, 2.54mm, 3x2, Gold, TH", Color=Black, Manufacturer="Wurth Elektronik", PartNumber=61300621121, Supplier Part Number 1=732-5295-ND
L1: library part CMP-0003154-2, "Ferrite Bead, 110 ohm @ 100 MHz, 4.1 A, 0603", Manufacturer="Wurth Elektronik", Supplier Part Number 1=732-6116-1-ND, Value1="0.0145 ohm", Value2=4.1A, ValueDisplayed="110 ohm"
Logo1: library part CMP-0074844-2, Manufacturer="Texas Instruments"
Logo2: library part CMP-0074838-1, "Texas Instrument Corporate Signature"
Logo3: library part CMP-0074847-1, "FCC_disclaimer"
Logo4: library part CMP-0074769-4, Manufacturer="Texas Instruments"
LOGO5 LOGO6: library part CMP-0074837-2, "IEC 61010-1 Hot Surface Warning", Manufacturer="Texas Instruments"
NT1 NT2 NT3: library part CMP-0078142-6, "Single point connection between nets.", Manufacturer=N/A
Q1 Q2 Q3 Q4 Q5 Q6: library part CMP-0092295-1, "MOSFET 60-V, N channel NexFET power MOSFET, single D2PAK, 1.6 mOhm 3-DDPAK/TO-263 -55 to 175", Digikey Part Number=296-44122-1-ND, Drain To Source Breakdown Voltage=60V, Input Capacitace At Vds="8790pF @ 30V", Manufacturer="Texas Instruments", Mouser Part Number=595-CSD18536KTTT, Operating Temperature Range="-55°C to +175°C", Power_W=375W, Pulse Drain Current=400A, Typ Forward Diode Voltage=0.9V
Q7: library part CMP-0000817-1, "MOSFET, N-CH, 60 V, 50 A, DQJ0008A (VSONP-8)", Alternate Manufacturer=None, Manufacturer="Texas Instruments", Supplier Part Number 1=296-35583-1-ND, Value1=0.009, Value2="22 nC"
R1 R2 R3 R4 R5 R6 R11 R12 R43 R45 R49 R55 R56 R57: library part CMP-0025874-4, "RES, 0, 5%, 0.1 W, AEC-Q200 Grade 0, 0603", Manufacturer=Panasonic, Power_W=100mW, Supplier Part Number 1=P0.0GCT-ND, TempCo="600 ppm/C", Tolerance_%=5%, Value2=0.1W, Value_Code=0000, ValueDisplayed=0
R7 R8 R9 R10 R58 R59 R62: library part CMP-0025830-4, "RES, 5.1 k, 5%, 0.1 W, AEC-Q200 Grade 0, 0603", Manufacturer=Vishay-Dale, Power_W=100mW, Supplier Part Number 1=541-5.1KGCT-ND, TempCo="200 ppm/C", Tolerance_%=5%, Value2=0.1W, Value_Code=5k10, ValueDisplayed=5.1k
R13 R14: library part CMP-0025941-5, "RES, 820, 5%, 0.1 W, 0603", Manufacturer=Yageo, Power_W=100mW, Supplier Part Number 1=311-820GRCT-ND, TempCo="100 ppm/C", Tolerance_%=5%, Value2=0.1W, Value_Code=820R, ValueDisplayed=820
R15: library part CMP-0023463-3, "RES, 2.00 k, 0.1%, 0.1 W, 0603", Manufacturer="Susumu Co Ltd", Power_W=100mW, Supplier Part Number 1=RG16P2.0KBCT-ND, TempCo="25 ppm/C", Tolerance_%=0.1%, Value2=0.1W, Value_Code=2k00, ValueDisplayed=2.00k
R16: library part CMP-0025925-5, "RES, 47 k, 5%, 0.1 W, 0603", Manufacturer=Yageo, Power_W=100mW, Supplier Part Number 1=311-47KGRCT-ND, TempCo="100 ppm/C", Tolerance_%=5%, Value2=0.1W, Value_Code=47k0, ValueDisplayed=47k
R17 R18: library part CMP-0025924-5, "RES, 470, 5%, 0.1 W, 0603", Manufacturer=Yageo, Power_W=100mW, Supplier Part Number 1=311-470GRCT-ND, TempCo="100 ppm/C", Tolerance_%=5%, Value2=0.1W, Value_Code=470R, ValueDisplayed=470
R19 R20 R21 R23 R24 R48 R52 R53: library part CMP-0086251-1, "RES, 10.0 k, 0.05%, 0.1 W, AEC-Q200 Grade 0, 0603", Manufacturer=Panasonic, Power_W=100mW, TempCo="10 ppm/C", Tolerance_%=0.05%, Value2=0.1W, Value_Code=10k0, ValueDisplayed=10.0k
R22 R60 R75 R76 R77 R78: library part CMP-0025701-4, "RES, 10 k, 5%, 0.1 W, AEC-Q200 Grade 0, 0603", Manufacturer=Vishay-Dale, Power_W=100mW, Supplier Part Number 1=541-10KGCT-ND, TempCo="200 ppm/C", Tolerance_%=5%, Value2=0.1W, Value_Code=10k0, ValueDisplayed=10k
R25 R26 R27 R40 R41 R42: library part CMP-0016763-3, "RES, 1.50, 1%, 0.25 W, AEC-Q200 Grade 0, 1206", Manufacturer=Vishay-Dale, Power_W=250mW, Supplier Part Number 1=53K1888, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.25W, Value_Code=1R50, ValueDisplayed=1.50
R28 R29 R30 R31 R32 R33 R34 R35 R36 R37 R38 R39: library part CMP-0025703-4, "RES, 10, 5%, 0.1 W, AEC-Q200 Grade 0, 0603", Manufacturer=Vishay-Dale, Power_W=100mW, Supplier Part Number 1=541-10GCT-ND, TempCo="200 ppm/C", Tolerance_%=5%, Value2=0.1W, Value_Code=10R0, ValueDisplayed=10
R44: library part CMP-0121773-1, "5 mOhms ±1% 7W Chip Resistor Nonstandard Automotive AEC-Q200, Current Sense, Moisture Resistant, Pulse Withstanding Metal Element", Digikey Part Number=541-2621-1-ND, Manufacturer=Vishay, Mouser Part Number=71-WSHM28185L000FEA, Operating Temperature Range="-65°C to +170°C", Power_W=7W, TempCo=200ppm/°C, Tolerance_%=1%
R46: library part CMP-0025874-4, "RES, 0, 5%, 0.1 W, AEC-Q200 Grade 0, 0603", Manufacturer=Panasonic, Power_W=100mW, Supplier Part Number 1=P0.0GCT-ND, TempCo="600 ppm/C", Tolerance_%=5%, Value2=0.1W, Value_Code=0000
R47: library part CMP-0001776-2, "Trimmer Potentiometer, 25kohm, 0.5W, TH", Manufacturer=Bourns, Supplier Part Number 1=3352T-253LF-ND
R50: library part CMP-0085900-1, "RES, 1.00 M, 1%, 0.1 W, AEC-Q200 Grade 0, 0603", Manufacturer="Stackpole Electronics Inc", Power_W=100mW, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.1W, Value_Code=1M00, ValueDisplayed=1.00M
R51: library part CMP-0023630-3, "RES, 100 k, 0.1%, 0.1 W, 0603", Manufacturer="Yageo America", Power_W=100mW, Supplier Part Number 1=603-RT0603BRD07100KL, TempCo="25 ppm/C", Tolerance_%=0.1%, Value2=0.1W, Value_Code=100k
R54: library part CMP-0024269-3, "RES, 47.0, 0.1%, 0.1 W, 0603", Manufacturer="Yageo America", Power_W=100mW, TempCo="25 ppm/C", Tolerance_%=0.1%, Value2=0.1W, Value_Code=47R0, ValueDisplayed=47.0
R64: library part CMP-0023630-3, "RES, 100 k, 0.1%, 0.1 W, 0603", Manufacturer="Yageo America", Power_W=100mW, Supplier Part Number 1=603-RT0603BRD07100KL, TempCo="25 ppm/C", Tolerance_%=0.1%, Value2=0.1W, Value_Code=100k, ValueDisplayed=100K
S1 S2 S3: library part CMP-0002155-2, "SWITCH TOGGLE SPDT 0.4VA 28V", CurrentRating_mA=100A, Manufacturer="NKK Switches", PartNumber=B12AP, Supplier Part Number 1=360-1012-ND
S4: library part CMP-0002155-2, "SWITCH TOGGLE SPDT 0.4VA 28V", CurrentRating_mA=100A, Manufacturer="NKK Switches", Supplier Part Number 1=360-1012-ND
S5: library part CMP-0002196-2, "Switch, Tactile, SPST, 12 V, SMD", CurrentRating_mA=50A, Manufacturer="Wurth Elektronik", PartNumber=434121025816, Supplier Part Number 1=31T8978
SH-J1 SH-J2 SH-J3 SH-J4 SH-J5 SH-J6 SH-J7 SH-J8 SH-J10 SH-J11 SH-J12 SH-J13 SH-J14 SH-J15 SH-J16 SH-J17 SH-J18 SH-J19 SH-J20 SH-J21 SH-J22 SH-J23 SH-J24 SH-J25: library part CMP-0003761-2, "Shunt, 2.54mm, Gold, Black", Manufacturer="Wurth Elektronik", Supplier Part Number 1=732-2678-ND
SW1: library part CMP-0002204-2, "Switch, DPDT, On-On, 0.4 VA, 28 V, TH", CurrentRating_mA=400A, Manufacturer="NKK Switches", Supplier Part Number 1=360-2791-ND
TP1 TP10 TP14 TP30 TP40 TP41 TP42 TP43 TP44 TP45: library part CMP-0055137-1, "Test Point, Miniature, Red, TH", Color=Red, Manufacturer=Keystone, PartNumber=5000, Supplier Part Number 1=36-5000-ND
TP2 TP3 TP4 TP5 TP26 TP31 TP32 TP33: library part CMP-0055139-1, "Test Point, Miniature, White, TH", Color=White, Manufacturer=Keystone, PartNumber=5002, Supplier Part Number 1=36-5002-ND
TP8 TP12 TP25: library part CMP-0055138-1, "Test Point, Miniature, Black, TH", Color=Black, Manufacturer=Keystone, PartNumber=5001, Supplier Part Number 1=36-5001-ND
TP9 TP11 TP15 TP16 TP17 TP18 TP19 TP20 TP39: library part CMP-0055152-1, "Test Point, Miniature, SMT", Manufacturer=Keystone, PartNumber=5015, Supplier Part Number 1=36-5015TR-ND
TP21 TP23 TP24: library part CMP-0075110-1, "1mm Uninsulated Shorting Plug, 10.16mm spacing, TH", Manufacturer=Harwin, PartNumber=D3082-05, Supplier Part Number 1=952-1873-ND
TP27 TP28 TP29: library part CMP-0055153-1, "Test Point, Compact, SMT", Manufacturer=Keystone, PartNumber=5016, Supplier Part Number 1=36-5016TR-ND
U1: library part CMP-0127057-1, "Sensorless Field Oriented Control (FOC) Three-phase BLDC Gate Driver", Manufacturer="Texas Instruments", Max Supply Voltage=60V, Min Supply Voltage=4.5V, Nominal Supply Current=28mA, Operating Temperature Range="-40°C to +150°C", Switching Frequency=75kHz
U2: library part CMP-0067444-2, "4-Bit Bidirectional Voltage-Level Shifter for Open-Drain and Push-Pull Applications, PW0014A (TSSOP-14)", Alternate Manufacturer="Texas Instruments", Operating Temperature Range="-40 to 85 C", Rating=Catalog
U3: library part CMP-0121693-1, "UART Interface IC USB Full Speed to Serial UART IC, Includes Oscillator and EEPROM, SSOP-28", Digikey Part Number=768-FT232RNL-REELCT-ND, Manufacturer=FTDI, Max Supply Voltage=5.25V, Min Supply Voltage=1.8V, Mouser Part Number=895-FT232RNL-REEL, Nominal Supply Current=7mA, Operating Temperature Range="-40°C to +85°C"
U4: library part CMP-0043115-3, "4-Channel ESD Protection Array for High-Speed Data Interfaces, DRY0006A (USON-6)", Breakdown Voltage(Min)(V)=6, IO Capacitance(Typ)(pF)=1.6, IO Leakage Current(nA)=1, Manufacturer="Texas Instruments", Operating Temperature Range="-40 to 85 C", Rating=Catalog
U5: library part CMP-0089204-1, "CPU16 MSP430™ FRAM Microcontroller IC 16-Bit 24MHz 32KB (32K x 8) FRAM 48-LQFP (7x7)", Digikey Part Number=296-50261-1-ND, Frequency_Fixed=24MHz, Manufacturer="Texas Instruments", Max Supply Voltage=3.6V, Min Supply Voltage=1.8V, Mouser Part Number=595-MSP430FR2355TPTR, Operating Temperature Range="-40°C to +105°C"
Y1: library part CMP-0084387-1, "Resonator, 4 MHz, 39 pF, AEC-Q200 Grade 1, SMD", Frequency_Fixed=4MHz, Load Capacitance="39 pF", Manufacturer=MuRata
ZZ1: library part CMP-0003616-3
ZZ2: library part CMP-0077236-1
ZZ3: library part CMP-0077237-1
ZZ4: library part CMP-0077238-1

## Free pads (board coordinates)
  rect 125.2x270.08 smd: 5(902.42,2072) 5(1079.58,2072)

## Via types
v1: diameter 20, hole 10, Top Layer to Bottom Layer, tented both sides, 906 vias
v2: diameter 19.68, hole 7.87, Top Layer to Bottom Layer, tented both sides, 8 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point)
3V3_MCU: C40.1 C49.1 D4.1 J7.2 J8.2 J14.1 R16.2 R17.2 R18.2 R58.2 R59.2 R64.2 TP45.1 U2.1 U2.8 U5.6 | length 4877.9
  Top Layer w10: C40.1@1490.95,706.66 1515.84,681.77 1639.78,681.77 U2.1@1642.9,678.65 ; U2.1@1642.9,672.28 U2.1@1642.9,678.65 ; U2.8@1796.45,904.56 1796.45,894.43 1800.01,890.86 1823.7,890.86 1869.41,845.16 R64.2@1870.39,845.16 1871.38,845.16 1951.32,925.1 v1(1980.49,925.1) ; R16.2@1798,301.56 1798,346 v1(1779,365) 1846,365 v1(1847,364) ; 2215.53,301.53 2215.53,257 2232,240.53 v1(2232,232) 2263.59,200.41 2448.39,200.41 2454.25,206.27 2454.25,326.83 2483.94,356.52 2483.94,357.5 2497.75,371.31 R59.2@2572.29,371.31 ; 2268,354 2268,432.52 U5.6@2268.16,432.68 ; TP45.1@3145,1194 3145,1181.3 2954.39,990.69 2407.15,990.69 2316.45,900 v1(2072.88,900) 2072.88,803.69 2018.18,748.98 1936.56,748.98 R18.2@1936.56,748 1936.56,671 R17.2@1935.56,670 1890.56,715 1847.19,715 1829.92,732.27 1679.05,732.27 1646.76,699.98 1646.76,696.93 1642.9,693.07 U2.1@1642.9,678.65
  Top Layer w19.68: TP45.1@3145,1194 3285.31,1334.31 D4.1@3298,1334.31 3298,1348 J8.2@3493,1543
  Top Layer w20: C49.1@2168.94,301.53 2215.53,301.53 2268,354
  Bottom Layer w10: J14.1@986.45,178.34 986.45,250 1027.15,290.7 1078,290.7 1704.7,290.7 v1(1779,365) ; v1(1980.49,925.1) 2047.78,925.1 v1(2072.88,900) ; v1(2232,232) 2232,229.29 2329,132.29 J7.2@2329,125
3V3COM: C16.2 D4.2 J8.3 TP41.1 U3.4 U3.17 | length 1494.5
  Top Layer w15: C16.2@2607,801.47 2611.78,806.25 2728.83,806.25 U3.4@2729.35,806.77 ; U3.4@2726.88,805.44 2727.35,805.91 2840.09,805.91 2902,744 2902,631 2931.82,601.18 U3.17@2999,601.18
  Top Layer w19.68: 2840.09,805.91 2981.19,947 3048,947 TP41.1@3145,1044 3298,1197 D4.2@3298,1247.69 3493,1442.69 J8.3@3493,1443
3V3EXT: J8.1 TP44.1 | length 521.9
  Top Layer w19.68: J8.1@3493,1643 3582,1554 3582,1281 TP44.1@3495,1194
5V_EXT: J6.1 TP43.1 | length 207.2
  Top Layer w7.87: J6.1@3495,841 J6.1@3498,838
  Top Layer w20: J6.1@3495,841 TP43.1@3495,1044
5V_USB: C11.2 J6.3 L1.1 TP42.1 U4.6 | length 742.8
  Top Layer w7.87: U4.6@3011.69,440.19 3024.87,427 v1(3039,427)
  Top Layer w29.53: v1(2992,377.56) 2977,362.56 2977,330.56 3042,330.56 3349.44,638 J6.3@3498,638 J6.3@3492,632
5VCC: C46.2 C47.2 J6.2 U3.20 | length 561.3
  Top Layer w10: U3.20@3001,678.82 C46.2@3155.74,678.82
  Top Layer w25: C46.2@3155.74,678.82 3157,680.08 3157,742.17 3493.83,742.17 J6.2@3498,738
AVDD: C1.2 C2.2 J1.2 J2.2 J9.11 J12.2 J14.3 J15.2 R7.1 R8.2 R9.2 R10.2 R19.2 R21.2 R24.2 R52.2 R62.1 TP10.1 U1.26 | length 7799.4
  Top Layer w7.87: 1726,1621 1726.5,1621.5 ; C1.2@1775,1621.5 1775.44,1621.5 R8.2@1775.44,1568 ; C2.2@1832.49,1621.5 1832.49,1628.49 1882.63,1678.63 U1.26@1920.2,1678.63 ; R10.2@1885,1397.44 R10.2@1885.81,1397.44 ; v1@1913.15,1370.1 R10.2@1885.81,1397.44 ; R9.2@1943,1397.44 R10.2@1885.81,1397.44 ; R7.1@2077,1430.71 2078,1429.71 v1(2078,1396)
  Top Layer w10: v1(2078,1396) 2110.75,1363.25 2110.75,1172.59 J9.11@2104.16,1166 ; R62.1@3398.48,2194.56 3431.54,2194.56 J15.2@3521.71,2104.39
  Top Layer w15: v1(1591,1612) 1591.32,1612.32 1717.32,1612.32 1726,1621 ; 1726.5,1621.5 C1.2@1775,1621.5 ; C1.2@1775.44,1621.5 C2.2@1832.49,1621.5
  Top Layer w25: R24.2@481,1605.56 541.44,1605.56 v1(542,1605) ; R21.2@482,1199.56 539.56,1199.56 v1(540,1200) ; R19.2@483,765.56 538.56,765.56 v1(539,766) ; R52.2@623.5,1822 711.5,1734 TP10.1@788,1734
  Power Layer w50: v1@540,1605 v1(540,1200) 540,377.83 575.95,341.87 735.81,341.87 786.45,291.23 J14.3@786.45,178.34 ; v1@540,1607 667,1734 TP10.1@788,1734 797,1725 J1.2@1009,1725 1009,1723.06 1111.06,1621 1582,1621 v1(1591,1612) 1630,1573 1630,1397 1697,1330 1891,1330 1923,1362 v1(1923,1370.87) ; v1(2078,1396) 2079.13,1394.87 2079.13,1378.24 2124.37,1333 2929,1333 J2.2@3080,1484 3023,1484 2821.29,1685.71 2606.71,1685.71 2565,1644 J12.2@2565,1581
  Bottom Layer w10: v1(1923,1370.87) 2052.87,1370.87 v1(2078,1396) ; J12.2@2565,1581 2664.19,1680.19 3030.26,1680.19 3269.1,1919.03 3336.34,1919.03 J15.2@3521.71,2104.39
BRAKE: J9.27 U1.34 | length 1024
  Top Layer w7.87: 1336,1158 1336,1164 v1(1489,1317) ; U1.34@2018.62,1623.51 2018.62,1601.44 2035.92,1584.14 2036.7,1584.14 2076.81,1544.03 2076.81,1543.29 2083,1537.1 v1(2083,1533.82)
  Bottom Layer w7.87: v1(1489,1317) 1495,1317 1580.19,1402.19 1766.61,1402.19 1768.68,1404.26 1955.1,1404.26 2083,1532.15 v1(2083,1533.82)
BRAKE_SW: J9.28 S1.2 TP26.1 | length 1275.5
  Top Layer w10: S1.2@268,677.95 639.95,677.95 TP26.1@641,679 641,770.29 864.89,994.19 1275.19,994.19 1304.16,1023.15 J9.28@1304.16,1066
BSTA: C8.1 J4.2 U1.9 | length 770.6
  Top Layer w7.87: U1.9@2069.8,1773.12 2086.8,1773.12 2106.98,1793.3 2193.11,1793.3 2234.07,1834.25 2465.81,1834.25 C8.1@2530.56,1899
  Top Layer w25: C8.1@2530.56,1899 2603,1899 J4.2@2734,2030
BSTB: C9.2 J4.6 U1.13 | length 446.1
  Top Layer w7.87: U1.13@2018.62,1812.49 2018.62,1834.56 2041.06,1857 2129.99,1857 C9.2@2175.12,1902.13
  Top Layer w25: C9.2@2175.12,1902.13 2222.99,1950 2292,1950 2335,1993 J4.6@2335,2035
BSTC: C10.2 J4.10 U1.17 | length 254
  Top Layer w7.87: C10.2@1907.56,1901 1907.56,1877 1944.18,1840.38 1944.62,1840.38 1955.63,1829.37 U1.17@1955.63,1812.49
  Top Layer w25: C10.2@1907.56,1901 1907.56,1949.56 1935,1977 J4.10@1935,2035
CPH: C3.2 U1.7 | length 117.4
  Top Layer w7.87: U1.7@2069.8,1741.62 2176.38,1741.62 C3.2@2184,1734
CPL: C3.1 U1.6 | length 226.7
  Top Layer w7.87: U1.6@2069.8,1725.87 2118.92,1725.87 2154.11,1690.69 2220.69,1690.69 C3.1@2264,1734
DACOUT/SOX/SPEED_ANA: J9.15 R3.1 TP2.1 U1.33 | length 2123.6
  Top Layer w7.87: R3.1@1522,1430.36 1526.36,1430.36 1562,1466 1694,1466 v1(1736,1424) ; J9.15@1904.16,1166 1936,1197.84 1936,1256.8 2031,1351.8 2031,1509.15 2055,1533.15 v1(2055,1535) 2049,1535 2048.81,1535.19 2048.81,1545.03 2002.87,1590.97 U1.33@2002.87,1623.51
  Top Layer w10: J9.15@1904.16,1166 1952.8,1117.36 2784.85,1117.36 TP2.1@2831.16,1071.05
  Bottom Layer w7.87: v1(1736,1424) 1945.85,1424 2055,1533.15 v1(2055,1535)
DACOUT_SPEED_ANA: J9.16 SW1.5 | length 1313.9
  Top Layer w10: SW1.5@1011,578 1011,830.14 1117.72,936.86 v1(1282.74,936.86)
  Bottom Layer w10: v1(1282.74,936.86) 1586.5,936.86 1589,934.36 1890.06,934.36 1904.16,948.46 J9.16@1904.16,1066
DIR: J9.29 R6.1 U1.31 | length 1148.3
  Top Layer w7.87: R6.1@1378,1430.36 1445.14,1497.5 1707.05,1497.5 1720.54,1484 1721.54,1485 v1(1734,1485) ; U1.31@1971.38,1623.51 1971.38,1568.68 1999.05,1541 v1(1999.05,1536)
  Top Layer w10: J9.29@1204.16,1166 1213.17,1175 1242.3,1175 1335.61,1268.31 1335.61,1388.95 1377.02,1430.36 R6.1@1378,1430.36
  Bottom Layer w7.87: v1(1734,1485) 1738.85,1485 1760.85,1463 1927.85,1463 1999.05,1534.21 v1(1999.05,1536)
DIR_SW: J9.30 S3.2 TP32.1 | length 1135.3
  Top Layer w10: S3.2@269,1528 269,1521.82 634.82,1521.82 TP32.1@641,1528 1045.13,1123.87 1082.15,1123.87 1085.37,1120.65 1149.51,1120.65 J9.30@1204.16,1066
DM: J5.2 U3.16 U4.5 | length 595
  Top Layer w10: J5.2@2917.59,197 2921.45,200.86 2921.45,228.36 2940,246.91 2940,378.21 2967.23,405.43 3008.48,405.43 3009,405.95 ; U4.5@2992,440.19 2992,422.95 3009,405.95 ; U3.16@3001,576.46 3001,572.6 3042.48,572.6 3055.21,559.87 3055.21,559.79 3077,538 3077,432.65 3045.35,401 3013.95,401 3009,405.95
DP: J5.3 U3.15 U4.2 | length 524.4
  Top Layer w10: J5.3@2892,197 2892,501 2941.87,550.87 3001,550.87 2992,541.87 U4.2@2992,463.81
DRVOFF: J9.31 U1.24 | length 1088.2
  Top Layer w7.87: v1(1721,1693) 1728.41,1693 1751.41,1715.99 1856.09,1715.99 1861.95,1710.13 U1.24@1920.2,1710.13
  Bottom Layer w10: J9.31@1104.16,1166 1146.14,1207.98 1146.14,1235.38 1177.61,1266.85 1339.02,1266.85 1721,1648.83 v1(1721,1693)
DRVOFF_SW: J9.32 S2.2 TP31.1 | length 852.3
  Top Layer w12: S2.2@268,1105 TP31.1@641,1105 653.99,1092.01 1070.65,1092.01 1096.66,1066 J9.32@1104.16,1066
DVDD: C4.2 TP1.1 U1.36 | length 1563.3
  Top Layer w7.87: U1.36@2050.12,1623.51 2050.12,1621.04 2122.72,1548.43 2122.72,1525.24 2163,1484.96 2163,1439 v1(2223,1379)
  Bottom Layer w7.87: v1(2223,1379) 2244.98,1357.02 2772.02,1357.02 3197,1782 TP1.1@3285,1782
EXT_CLK: J15.3 R1.1 R46.2 R50.2 R62.2 U1.32 | length 2963.9
  Top Layer w7.87: v1(1450,1468) R1.1@1450,1430.36 1501.39,1481.75 1700.52,1481.75 1725.27,1457 v1(1736,1457) ; U1.32@1987.13,1623.51 1987.13,1578.77 2020.87,1545.03 2020.87,1536.13 2021,1536 v1(2027,1536)
  Top Layer w10: R62.2@3398.48,2139.44 3399.46,2139.44 3426.84,2112.07 3426.84,2105.15 3491.37,2040.61 ; R46.2@3402.9,1949.53 R50.2@3402.9,2009.5 3402.9,2010.49 3416.6,2024.19 3417.58,2024.19 3434,2040.61 3491.37,2040.61 ; J15.3@3521.71,2004.39 3521.71,2010.28 3491.37,2040.61
  Bottom Layer w7.87: v1(1736,1457) 1748,1445 1938.9,1445 2027,1533.1 v1(2027,1536)
  Bottom Layer w10: v1(2027,1536) 2027,1538.71 2032.13,1543.83 2032.13,1544.47 2045.53,1557.87 2177.92,1557.87 2330.69,1405.1 2780.45,1405.1 3275.35,1900 3345.29,1900 3449.1,2003.82 3521.13,2003.82 J15.3@3521.71,2004.39
FGOUT: J9.5 R8.1 TP4.1 U1.28 | length 1648.4
  Top Layer w7.87: v1(1781.55,1382.45) 1783.86,1384.75 1783.86,1521.3 R8.1@1830.56,1568 1839.26,1568 1894.81,1623.55 1894.81,1632.25 1909.69,1647.13 U1.28@1920.2,1647.13 ; J9.5@2404.16,1166 2413.77,1175.61 2448.45,1175.61 2539.69,1266.85 2858.97,1266.85 TP4.1@2931.82,1194
  Bottom Layer w7.87: v1(1781.55,1382.45) 1825,1339 2028.15,1339 2031.97,1342.81 2227.35,1342.81 J9.5@2404.16,1166
GCTRL: R56.1 TP5.1 U1.3 | length 1718.3
  Top Layer w7.87: U1.3@2069.8,1678.63 2095.28,1678.63 2129.33,1644.57 v1(2129.33,1625) ; R56.1@3170.5,1698 3173,1698 3224,1749 3224,1911 TP5.1@3286,1973
  Bottom Layer w7.87: v1(2129.33,1625) 2533.81,1625 2605.81,1697 3010,1697 TP5.1@3286,1973
GHA: J4.4 R28.1 R31.1 U1.11 | length 1447.2
  Top Layer w7.87: U1.11@2050.12,1812.49 2053.49,1812.49 2065.8,1824.8 2180.07,1824.8 2222.27,1867 2315,1867 2344,1896
  Top Layer w25: 2344,1896 2396,1896 J4.4@2535,2035 ; R28.1@2505.94,2751.69 2505.94,2664.45 2501.5,2660 2501.5,2563.5 2558.19,2506.81 v1(2642,2506.81)
  GND Layer w25: J4.4@2535,2035 2642,2142 v1(2642,2506.81)
GHA_FET: C15.1 D5.2 Q1.1 R22.2 R28.2 TP15.1
GHB: J4.8 R29.1 R32.1 U1.15 | length 1395.7
  Top Layer w7.87: U1.15@1987.13,1812.49 1987.13,1875
  Top Layer w19.68: J4.8@2118.75,2031.75 J4.8@2135,2031.75
  Top Layer w25: R29.1@1490,2753.5 1490,2664.18 1469.95,2644.13 1469.95,2602.41 1527.89,2544.47 v1(1651.87,2544.47) ; 1987.13,1875 1987.13,1900.13 2061,1974 2102,1974 2135,2007 J4.8@2135,2031.75
  GND Layer w25: v1(1651.87,2544.47) 2135,2061.34 J4.8@2135,2035
GHB_FET: C17.1 D6.2 Q2.1 R29.2 R60.2 TP16.1
GHC: J4.12 R30.1 R33.1 U1.19 | length 2050.4
  Top Layer w7.87: 1813,1854 1872.27,1794.73 1914.33,1794.73 U1.19@1920.2,1788.87
  Top Layer w25: R30.1@425,2771.02 425,2679.47 421.92,2676.39 421.92,2628.08 485,2565 v1(592.9,2565) ; J4.12@1735,2035 1735,1932 1813,1854
  GND Layer w25: v1(592.9,2565) 1205,2565 J4.12@1735,2035
GHC_FET: C19.1 D7.2 Q3.1 R30.2 R75.2 TP17.1
GLA: J4.5 R34.1 R37.1 U1.12 | length 1218.5
  Top Layer w7.87: U1.12@2034.37,1812.49 2034.37,1828.04 2046.88,1840.54 2173.54,1840.54 2226,1893
  Top Layer w19.68: 2226,1893 2293,1893 J4.5@2435,2035
  Top Layer w25: v1(2587,2320) 2873.5,2320 2875,2318.5 R34.1@2955,2318.5
  GND Layer w25: J4.5@2435,2035 2587,2187 v1(2587,2320)
GLA_FET: C27.1 D8.2 Q4.1 R34.2 R76.2 TP18.1 | length 170.4
  Top Layer w25: R76.2@3053.44,2492 3052.44,2491 3052.44,2382.18 TP18.1@3095,2339.62
GLB: J4.9 R35.1 R38.1 U1.16 | length 930
  Top Layer w7.87: 1950,1893 1950,1860 1971.38,1838.62 U1.16@1971.38,1812.49
  Top Layer w25: v1(1720.5,2318.5) R35.1@1935,2318.5 ; 1950,1893 1950,1933 2035,2018 J4.9@2035,2035
  GND Layer w25: v1(1720.5,2318.5) 1761.01,2278 1821,2278 2035,2064 J4.9@2035,2035
GLB_FET: C28.1 D9.2 Q5.1 R35.2 R77.2 TP19.1
GLC: J4.13 R36.1 R39.1 U1.20 | length 1742.7
  Top Layer w7.87: 1667,1904 1722,1904 1847.02,1778.98 1882.18,1778.98 1888.04,1773.12 U1.20@1920.2,1773.12
  Top Layer w25: v1(682,2341) 810.41,2341 812.41,2339 813.96,2340.55 R36.1@891.77,2340.55 ; J4.13@1635,2035 1635,1936 1667,1904
  GND Layer w25: v1(682,2341) 890,2133 1537,2133 J4.13@1635,2035
GLC_FET: C29.1 D10.2 Q6.1 R36.2 R78.2 TP20.1 | length 176.7
  Top Layer w20: C29.1@960.44,2471 960.44,2522.17 R78.2@962.26,2523.99
  Top Layer w50: 931.5,2405.62 963.11,2374.02 TP20.1@1041.38,2374.02
GND: C1.1 C2.1 C4.1 C5.1 C6.2 C7.1 C11.1 C16.1 C18.2 C20.2 C30.1 C32.2 C33.2 C34.2 C35.2 C36.2 C37.1 C38.2 C39.2 C40.2 C41.1 C44.2 C46.1 C47.1 C48.2 C49.2 J4.1 J5.5 J5.6 J5.7 J5.8 J5.9 J5.10 J5.11 J7.1 J9.1 J9.2 J10.2 J15.1 pad.5@902.42,2072 R1.2 R2.2 R3.2 R4.2 R5.2 R6.2 R13.1 R15.1 R20.1 R23.1 R44.1 R45.2 R47.3 R48.1 R50.1 R51.1 R53.1 R64.1 S5.2 TP8.1 TP12.1 TP21.1 TP21.2 TP23.1 TP23.2 TP24.1 TP24.2 TP25.1 U1.1 U1.4 U1.25 U1.37 U2.7 U3.7 U3.18 U3.21 U3.25 U3.26 U4.3 U5.7 Y1.2 | length 681.4
  Top Layer w7.87: C1.1@1775,1684.5 C2.1@1832.49,1684.5 1842.37,1694.38 U1.25@1920.2,1694.38 ; U1.1@2069.8,1647.13 2069.8,1627.2 2071.61,1629 v1(2074,1629) ; U1.4@2069.8,1694.38 2105.88,1694.38 2152.4,1647.85 v1(2152.4,1647.13) ; v1(2280,485) 2287.84,477.16 U5.7@2287.84,432.68 ; v1(2941.87,483) 2961.06,463.81 U4.3@2972.32,463.81
  Top Layer w8: R44.1@856.42,2080 R44.1@902,2080 ; pad.5@902.42,2072 920.42,2054 971.12,2054 983,2042.12 983,1909 963,1889 R45.2@963,1881.56
  Bottom Layer w7.87: 2658,962.72 2658,966
  other v1: 62.8,119.6 437.87,122.62 537.87,122.62 637.87,122.62 737.87,122.62 837.87,122.62 937.87,122.62 1037.87,122.62 1637.87,122.62 2537.87,122.62 2637.87,122.62 3137.87,122.62 3237.87,122.62 487.87,222.62 587.87,222.62 687.87,222.62 1287.87,222.62 1387.87,222.62 1487.87,222.62 1587.87,222.62 2487.87,222.62 2587.87,222.62 2687.87,222.62 2349,272 62.8,319.6 437.87,322.62 1037.87,322.62 1137.87,322.62 1237.87,322.62 1337.87,322.62 2537.87,322.62 3137.87,322.62 87.87,422.62 187.87,422.62 387.87,422.62 487.87,422.62 587.87,422.62 687.87,422.62 787.87,422.62 887.87,422.62 1087.87,422.62 1187.87,422.62 1287.87,422.62 1387.87,422.62 1487.87,422.62 3187.87,422.62 3287.87,422.62 3487.87,422.62 62.8,519.6 137.87,522.62 337.87,522.62 437.87,522.62 637.87,522.62 737.87,522.62 837.87,522.62 1037.87,522.62 2037.87,522.62 2537.87,522.62 2637.87,522.62 2837.87,522.62 3037.87,522.62 3137.87,522.62 3337.87,522.62 3437.87,522.62 87.87,622.62 187.87,622.62 387.87,622.62 587.87,622.62 687.87,622.62 787.87,622.62 887.87,622.62 1087.87,622.62 1187.87,622.62 1287.87,622.62 1811.04,622.57 2187.87,622.62 2287.87,622.62 2387.87,622.62 2587.87,622.62 2787.87,622.62 3087.87,622.62 3192.03,622.62 1829.91,672.85 62.8,719.6 137.87,722.62 337.87,722.62 737.87,722.62 837.87,722.62 1037.87,722.62 1237.87,722.62 1337.87,722.62 1437.87,722.62 87.87,822.62 187.87,822.62 287.87,822.62 387.87,822.62 487.87,822.62 587.87,822.62 787.87,822.62 887.87,822.62 1087.87,822.62 1187.87,822.62 1287.87,822.62 1387.87,822.62 1487.87,822.62 1587.87,822.62 1687.87,822.62 3187.87,822.62 3287.87,822.62 3387.87,822.62 1970,840 2650.79,851.33 1970,870 62.8,919.6 137.87,922.62 337.87,922.62 437.87,922.62 737.87,922.62 837.87,922.62 937.87,922.62 3137.87,922.62 3237.87,922.62 3337.87,922.62 3437.87,922.62 87.87,1022.62 187.87,1022.62 587.87,1022.62 687.87,1022.62 787.87,1022.62 887.87,1022.62 987.87,1022.62 2687.87,1022.62 3287.87,1022.62 3387.87,1022.62 62.8,1119.6 137.87,1122.62 737.87,1122.62 837.87,1122.62 937.87,1122.62 1237.87,1122.62 1337.87,1122.62 1437.87,1122.62 1537.87,1122.62 1637.87,1122.62 1737.87,1122.62 1837.87,1122.62 3337.87,1122.62 3437.87,1122.62 87.87,1222.62 187.87,1222.62 587.87,1222.62 687.87,1222.62 787.87,1222.62 887.87,1222.62 987.87,1222.62 1087.87,1222.62 1187.87,1222.62 1787.87,1222.62 1887.87,1222.62 1987.87,1222.62 2087.87,1222.62 2187.87,1222.62 2287.87,1222.62 2587.87,1222.62 2687.87,1222.62 3387.87,1222.62 62.8,1319.6 137.87,1322.62 337.87,1322.62 437.87,1322.62 637.87,1322.62 737.87,1322.62 937.87,1322.62 1037.87,1322.62 1137.87,1322.62 1237.87,1322.62 3037.87,1322.62 3437.87,1322.62 1373,1335.63 1448.49,1338.26 87.87,1422.62 187.87,1422.62 587.87,1422.62 687.87,1422.62 787.87,1422.62 887.87,1422.62 987.87,1422.62 1087.87,1422.62 1187.87,1422.62 3087.87,1422.62 3187.87,1422.62 2842,1499 62.8,1519.6 137.87,1522.62 737.87,1522.62 837.87,1522.62 937.87,1522.62 1037.87,1522.62 1237.87,1522.62 87.87,1622.62 187.87,1622.62 687.87,1622.62 787.87,1622.62 887.87,1622.62 987.87,1622.62 3187.87,1622.62 3387.87,1622.62 62.8,1719.6 137.87,1722.62 337.87,1722.62 437.87,1722.62 537.87,1722.62 1237.87,1722.62 1337.87,1722.62 2337.87,1722.62 3237.87,1722.62 3337.87,1722.62 2399,1799 2347,1800 87.87,1822.62 187.87,1822.62 687.87,1822.62 787.87,1822.62 887.87,1822.62 1587.87,1822.62 2688.55,1877 62.8,1919.6 137.87,1922.62 337.87,1922.62 537.87,1922.62 637.87,1922.62 737.87,1922.62 2688,1926 87.87,2022.62 187.87,2022.62 287.87,2022.62 487.87,2022.62 587.87,2022.62 787.87,2022.62 62.8,2119.6 137.87,2122.62 237.87,2122.62 337.87,2122.62 437.87,2122.62 537.87,2122.62 637.87,2122.62 737.87,2122.62 3337.87,2122.62 87.87,2222.62 187.87,2222.62 287.87,2222.62 387.87,2222.62 487.87,2222.62 587.87,2222.62 62.8,2319.6 137.87,2322.62 237.87,2322.62 337.87,2322.62 437.87,2322.62 937.87,2322.62 3437.87,2322.62 87.87,2422.62 187.87,2422.62 287.87,2422.62 387.87,2422.62 587.87,2422.62 687.87,2422.62 3387.87,2422.62 3487.87,2422.62 62.8,2519.6 137.87,2522.62 237.87,2522.62 537.87,2522.62 637.87,2522.62 737.87,2522.62 3437.87,2522.62 87.87,2622.62 187.87,2622.62 387.87,2622.62 687.87,2622.62 3387.87,2622.62 3487.87,2622.62 62.8,2719.6 3437.87,2722.62 87.87,2822.62 187.87,2822.62 62.8,2919.6 137.87,2922.62 87.87,3022.62 187.87,3022.62 3487.87,3022.62 62.8,3119.6 3437.87,3122.62 87.87,3222.62 187.87,3222.62 1255,3250 1305,3250 1355,3250 2271.66,3290 2321.66,3290 2371.66,3290 1255,3300 1305,3300 1355,3300 62.8,3319.6 137.87,3322.62 237.87,3322.62 3437.87,3322.62 2271.66,3340 2321.66,3340 2371.66,3340 87.87,3422.62 3487.87,3422.62 62.8,3519.6 87.87,3622.62 3487.87,3622.62 62.8,3719.6 3437.87,3722.62 87.87,3822.62 3487.87,3822.62 62.8,3919.6 137.87,3922.62 3437.87,3922.62 87.87,4022.62 187.87,4022.62 287.87,4022.62 387.87,4022.62 3487.87,4022.62 62.8,4119.6 137.87,4122.62 237.87,4122.62 437.87,4122.62 537.87,4122.62 737.87,4122.62 837.87,4122.62 3437.87,4122.62 87.87,4222.62 187.87,4222.62 287.87,4222.62 387.87,4222.62 487.87,4222.62 587.87,4222.62 687.87,4222.62 787.87,4222.62 887.87,4222.62 987.87,4222.62 2987.87,4222.62 3087.87,4222.62 3187.87,4222.62 3287.87,4222.62 3387.87,4222.62 3487.87,4222.62 62.8,4319.6 137.87,4322.62 237.87,4322.62 337.87,4322.62 437.87,4322.62 537.87,4322.62 637.87,4322.62 737.87,4322.62 937.87,4322.62 1037.87,4322.62 1537.87,4322.62 2837.87,4322.62 2937.87,4322.62 3037.87,4322.62 3137.87,4322.62 3237.87,4322.62 3337.87,4322.62 3437.87,4322.62 87.87,4422.62 487.87,4422.62 587.87,4422.62 687.87,4422.62 787.87,4422.62 887.87,4422.62 987.87,4422.62 1087.87,4422.62 1487.87,4422.62 1587.87,4422.62 2787.87,4422.62 2887.87,4422.62 2987.87,4422.62 3087.87,4422.62 3187.87,4422.62 62.8,4519.6 437.87,4522.62 537.87,4522.62 637.87,4522.62 737.87,4522.62 837.87,4522.62 937.87,4522.62 1037.87,4522.62 1137.87,4522.62 1237.87,4522.62 1337.87,4522.62 1437.87,4522.62 1537.87,4522.62 1637.87,4522.62 1737.87,4522.62 1837.87,4522.62 1937.87,4522.62 2037.87,4522.62 2137.87,4522.62 2237.87,4522.62 2337.87,4522.62 2437.87,4522.62 2537.87,4522.62 2637.87,4522.62 2737.87,4522.62 2837.87,4522.62 2937.87,4522.62 3037.87,4522.62 3137.87,4522.62 87.87,4622.62 387.87,4622.62 687.87,4622.62 787.87,4622.62 887.87,4622.62 987.87,4622.62 1087.87,4622.62 1187.87,4622.62 1287.87,4622.62 1387.87,4622.62 1487.87,4622.62 1587.87,4622.62 1687.87,4622.62 1787.87,4622.62 1887.87,4622.62 1987.87,4622.62 2087.87,4622.62 2187.87,4622.62 2287.87,4622.62 2387.87,4622.62 2487.87,4622.62 2587.87,4622.62 2687.87,4622.62 2787.87,4622.62 2987.87,4622.62 3187.87,4622.62
  other v2: 1995,1655.01 1951.69,1693.39 1995,1693.39 2038.31,1693.39 1951.69,1742.61 1995,1742.61 2038.31,1742.61 1995,1780.99
GVDD: C5.2 TP40.1 U1.8 | length 1442.3
  Top Layer w7.87: U1.8@2069.8,1757.37 2093.32,1757.37 2113.5,1777.55 2201.64,1777.55 2226.08,1802 C5.2@2258.98,1802 ; C5.2@2250.44,1800 2257,1800 v1@2273.63,1783.37 ; v1(2271.94,1783.37) v1@2273.63,1783.37 ; v1@2277,1780 v1@2273.63,1783.37
  Bottom Layer w7.87: v1(2271.94,1783.37) 2302.31,1753 2872,1753 TP40.1@3286,2167
ID: J5.4 U4.4 | length 305.6
  Top Layer w10: v1(2866,254) 2866,197.41 J5.4@2866.41,197 ; v1(2917,274) 2917,384.87 U4.4@2972.32,440.19
  Bottom Layer w10: v1(2866,254) 2886,274 v1(2917,274)
LSS: C21.1 C22.1 C23.1 C27.2 C28.2 C29.2 J4.14 pad.5@1079.58,2072 Q4.3 Q5.3 Q6.3 R40.1 R41.1 R42.1 R43.2 R44.2 R76.1 R77.1 R78.1 TP9.1 U1.21 | length 2148.6
  Top Layer w7.87: R43.2@1020,1881.56 998.81,1902.75 998.81,2042.24 1010.57,2054 1061.58,2054 pad.5@1079.58,2072 ; 1571,1878 1715,1878 1829.76,1763.24 1875.65,1763.24 1881.52,1757.37 U1.21@1920.2,1757.37
  Top Layer w19.68: R77.1@2109.56,2429 C28.2@2109.56,2486
  Top Layer w25: J4.14@1535,2035 1535,1914 1571,1878
  Top Layer w50: C23.1@261.85,2981.65 261.85,2635.15 631.94,2265.06 1020,2265.06
  other v1: 1433.27,1989 1220,1991 1333,1991 1372.42,2064 1220.5,2066 1295.5,2066 1445.5,2066 1783,2141 1858,2141 2008,2141 2158,2141 2233,2141 2308,2141 2383,2141 2458,2141 2758,2141 2833,2141 2908,2141 1745.5,2216 1820.5,2216 2120.5,2216 2195.5,2216 2270.5,2216 2345.5,2216 2420.5,2216 2495.5,2216 2795.5,2216 2870.5,2216 2945.5,2216 3020.5,2216 1373,2240.1 1259,2242 1165.82,2244 1633,2291 2233,2291 2308,2291 2383,2291 2458,2291 2533,2291 1165.82,2343.44 1260,2343.44 1367,2344.49 1670.5,2366 1745.5,2366 2195.5,2366 2270.5,2366 2345.5,2366 2420.5,2366 2495.5,2366 2570.5,2366 2795.5,2366 1165.82,2424 1259,2424 1483,2441 1558,2441 1633,2441 1708,2441 2233,2441 2308,2441 2383,2441 2458,2441 2533,2441 2608,2441 2758,2441 2833,2441 3208,2441 1097,2489 1165,2489.83 1445.5,2516 1820.5,2516 2195.5,2516 2270.5,2516 2345.5,2516 2420.5,2516 2495.5,2516 2795.5,2516 3170.5,2516 1333,2591 1408,2591 1783,2591 2008,2591 2158,2591 2233,2591 2308,2591 2383,2591 2458,2591 2533,2591 2758,2591 2833,2591 2983,2591 3058,2591 3208,2591 925,2616 1105,2616 1295.5,2666 1370.5,2666 1670.5,2666 1745.5,2666 1820.5,2666 1970.5,2666 2045.5,2666 2195.5,2666 2270.5,2666 2345.5,2666 2795.5,2666 3020.5,2666 3170.5,2666 871,2767.52 1124,2767.52 744,2769 1004.91,2769
LVL_AVDD: C41.2 J9.12 U2.14 | length 706.3
  Top Layer w10: v1@1597.49,901.91 v1(1595.57,900) 1639.34,900 1642.9,903.56 U2.14@1642.9,904.56 1642.9,921.18 1639.34,924.74 1628.72,924.74 C41.2@1599.5,953.96 C41.2@1597.49,951.95
  Bottom Layer w10: v1(1595.57,900) 1923.04,900 1971.01,947.97 1986.13,947.97 J9.12@2104.16,1066
LVL_FGOUT: J9.6 U2.11 | length 894.2
  Top Layer w10: U2.11@1719.68,904.56 1721.15,903.09 1721.15,832.5 1748.21,805.44 1978.89,805.44 2000.91,827.46 2000.91,860.61 2098.69,958.4 2296.56,958.4 J9.6@2404.16,1066
LVL_nFAULT: J9.8 U2.10 | length 639.7
  Top Layer w10: U2.10@1745.27,904.56 1745.27,925.35 1749.12,929.21 1749.12,932.27 1811.04,994.19 2232.35,994.19 J9.8@2304.16,1066
LVL_SCL: J9.22 U2.12 | length 215.9
  Top Layer w10: J9.22@1604.16,1066 1638.18,1031.98 1667.56,1031.98 1694.09,1005.45 U2.12@1694.09,904.56
LVL_SDA: J9.24 U2.13 | length 290
  Top Layer w10: J9.24@1504.16,1066 1514.38,1055.78 1514.38,1029.07 1526.36,1017.1 1584.87,1017.1 1667.02,934.95 1667.02,906.04 U2.13@1668.49,904.56 1668.49,883.78 U2.13@1664.64,879.92
MCX_SCL: J9.21 R9.1 R11.1 | length 611.6
  Top Layer w7.87: R11.1@1937.29,1508.73 1937.29,1458.27 R9.1@1943,1452.56
  Top Layer w10: J9.21@1604.16,1166 1667.21,1229.05 1697.06,1229.05 1806.43,1338.42 1917.22,1338.42 1917.8,1339 1949.71,1339 1972.61,1361.9 1972.61,1423.94 1943.98,1452.56 R9.1@1943,1452.56
MCX_SDA: J9.23 R10.1 R12.1 | length 555.6
  Top Layer w7.87: R10.1@1884.29,1453.27 R12.1@1884.29,1508.73
  Top Layer w10: J9.23@1504.16,1166 1600.62,1262.46 1694.9,1262.46 1873.27,1440.83 1873.27,1441.81 1884.02,1452.56 R10.1@1885,1452.56
MSP_A3_P1.3: SW1.4 U5.48 | length 1171
  Top Layer w7.87: SW1.4@1111,578 1150,539 v1(1198,539) ; U5.48@2108.71,493.7 U5.48@2109.77,492.64
  Top Layer w10: v1(1997.21,491.54) 2110.49,491.54 U5.48@2110.68,491.73 U5.48@2109.77,492.64
  Bottom Layer w7.87: v1(1198,539) 1198,464.7 1278.7,384 1747.27,384 1854.81,491.54 v1(1997.21,491.54)
MSP_FGOUT: U2.4 U5.29 | length 756.4
  Top Layer w10: U2.4@1719.68,672.28 1719.68,651.49 1723.53,647.63 1723.53,637.82 v1(1743.23,618.13) ; U5.29@2307.53,767.32 2307.53,701.15 2312.9,695.78 v1(2312.9,693.07)
  Bottom Layer w10: v1(1743.23,618.13) 1761.66,599.7 1906.11,599.7 1999.48,693.07 v1(2312.9,693.07)
MSP_LED0_P2.2: D13.2 U5.28 | length 529.6
  Top Layer w7.87: D13.2@1941.5,602.05 1973,633.55 1973,677.21 2102.49,806.69 2317.18,806.69 2325.24,798.63 2325.24,769.29 U5.28@2327.21,767.32
MSP_LED1_P2.2: D14.2 U5.27 | length 296.5
  Top Layer w7.87: D14.2@2103.28,849.84 2113.04,840.08 2306.07,840.08 2344.93,801.22 2344.93,769.29 U5.27@2346.9,767.32
MSP_nFAULT: U2.5 U5.44 | length 442.4
  Top Layer w10: U2.5@1745.27,672.28 1745.27,651.49 1749.12,647.63 1749.12,644.58 1820.28,573.43 1961.38,573.43 1974.22,586.26 1989.48,586.26 2018.11,557.64 2050.83,557.64 2062.76,569.57 U5.44@2110.68,569.57
MSP_POT: J9.10 U5.43 | length 866
  Top Layer w10: v1(2051,590.16) U5.43@2110.68,590.16
  Bottom Layer w10: v1(2051,590.16) 2300.04,590.16 2350.42,640.54 2350.42,919.74 J9.10@2204.16,1066
MSP_RX_P4.3: U3.5 U5.23 | length 320
  Top Layer w10: U5.23@2445.32,688.58 2585.04,688.58 2676.77,780.32 U3.5@2727.35,780.32
MSP_SBWTCK: J7.4 U5.4 | length 444.5
  Top Layer w10: J7.4@2129,125 2060,194 2060,294.28 2130.6,364.87 2193.87,364.87 2228.79,399.79 U5.4@2228.79,432.68 U5.4@2227.88,431.77
MSP_SBWTDIO/nRST: C48.1 J7.3 R16.1 S5.1 U5.5 | length 1305.9
  Top Layer w10: C48.1@1671.37,278.43 1765.02,278.43 1797.02,246.44 R16.1@1798,246.44 1855.49,246.44 S5.1@1948,338.95 1960.44,326.51 1960.44,168.56 2072,57 2161,57 J7.3@2229,125 2205,125 2118,212 2118,327 2138,347 2202,347 2248.47,393.47 U5.5@2248.47,432.68
MSP_SCL: R58.1 U2.3 U5.12 | length 980.3
  Top Layer w10: U2.3@1694.09,672.28 1694.09,622.57 v1(1714.61,602.05) ; v1(2305.69,520.04) 2336.98,488.75 2361.04,488.75 2386.27,463.52 U5.12@2386.27,432.68 2485.39,432.68 2494.69,423.37 R58.1@2495.68,423.37 ; U5.12@2385.36,449.01 U5.12@2385.36,453.43 ; R58.1@2494.3,432.68 R58.1@2494.61,432.99
  Bottom Layer w10: v1(1714.61,602.05) 1784.33,532.33 1989.47,532.33 2017.93,560.79 2264.94,560.79 v1(2305.69,520.04)
MSP_SDA: R59.1 U2.2 U5.13 | length 1093.4
  Top Layer w10: U2.2@1668.49,672.28 1669.93,670.84 1669.93,594.63 v1(1671.37,593.2) ; v1(2365.85,511.62) 2394.59,511.62 2413.57,492.64 2444.42,492.64 U5.13@2445.32,491.73 2506.01,491.73 2571.31,426.43 R59.1@2572.29,426.43
  Bottom Layer w10: v1(1671.37,593.2) 1750.11,514.45 2006.65,514.45 2061.54,459.56 2313.79,459.56 v1(2365.85,511.62)
MSP_TB0.1: J13.6 U5.42 | length 841.6
  Top Layer w10: J13.6@1347,500.79 1401.21,555 1979.8,555 v1(1980,555.2) ; v1(2013.55,624.23) 2057.08,624.23 2071.47,609.84 U5.42@2110.68,609.84
  Bottom Layer w10: v1(1980,555.2) 1980,590.69 v1(2013.55,624.23)
MSP_TX_P4.2: U3.1 U5.24 | length 415
  Top Layer w10: U5.24@2445.32,708.27 2495.68,708.27 2557,769.59 2557,861.25 2584.94,889.18 2629.06,889.18 2630.25,888 2724.89,888 U3.1@2729.35,883.54
MSP_XIN_P2.7: U5.8 Y1.1 | length 168
  Top Layer w10: Y1.1@2289.94,272 2289.94,337.42 2307.53,355 U5.8@2307.53,432.68
MSP_XOUT_P2.6: U5.9 Y1.3 | length 194.2
  Top Layer w10: U5.9@2327.21,432.68 2327.21,383.79 2408.06,302.94 Y1.3@2408.06,272
NetC12_2: C12.2 R25.2 | length 152.4
  Top Layer w39.37: R25.2@2863.43,3673.85 2863.43,3540.75 C12.2@2877.09,3527.09
NetC13_2: C13.2 R26.2 | length 146.2
  Top Layer w39.37: R26.2@1862.09,3670 1862.09,3527.91 C13.2@1865,3525
NetC14_2: C14.2 R27.2 | length 158.8
  Top Layer w39.37: C14.2@795,3512.09 797.09,3514.17 R27.2@797.09,3670
NetC24_2: C24.2 R41.2 | length 109.9
  Top Layer w39.37: R41.2@2275,2927.97 C24.2@2275,3037.91
NetC25_2: C25.2 R42.2 | length 125.8
  Top Layer w39.37: R42.2@1205,2847.09 C25.2@1205,2972.91
NetC26_2: C26.2 R40.2 | length 120.8
  Top Layer w39.37: R40.2@3285,2922.09 C26.2@3285,3042.91
NetC39_1: C39.1 Q7.4 R56.2 | length 224.7
  Top Layer w25: Q7.4@2962.64,1782.54 2960.46,1782.54 2975.91,1767.09 C39.1@2975.91,1698 R56.2@3107.5,1698
NetD1_1: D1.1 R13.2 | length 98.2
  Top Layer w7.87: D1.1@1110,1547.66 1166.5,1547.66 R13.2@1196,1577.16
NetD1_2: D1.2 J1.1 | length 95.1
  Top Layer w20: J1.1@1109,1725 1110,1724 D1.2@1110,1630.34
NetD2_1: D2.1 R14.2 | length 178.3
  Top Layer w7.87: R14.2@2843.56,1353 2920,1429.44 D2.1@2920,1499.66
NetD2_2: D2.2 J2.1 | length 160.7
  Top Layer w7.87: D2.2@2920,1582.34 3078.34,1582.34 J2.1@3080,1584
NetD3_1: D3.1 R15.2 | length 128.5
  Top Layer w19.68: R15.2@633,4049.44 638.56,4049.44 683.31,4004.69 D3.1@683.31,3945
NetD3_2: D3.2 J3.1 | length 175
  Top Layer w39.37: D3.2@765.98,3945 J3.1@941,3945
NetD5_1: D5.1 R31.2 | length 84.2
  Top Layer w20: D5.1@2421.3,2742.13 2435.08,2728.35 R31.2@2435.08,2663.66
NetD6_1: D6.1 R32.2 | length 89.6
  Top Layer w20: D6.1@1403.58,2732.28 1403.58,2647.5 R32.2@1406.95,2644.13
NetD7_1: D7.1 R33.2 | length 75.8
  Top Layer w20: D7.1@344.69,2744.69 344.69,2718.31 362.87,2700.13 R33.2@362.87,2676.39
NetD8_1: D8.1 R37.2 | length 84.9
  Top Layer w20: D8.1@2871.69,2465 2871.69,2384.8 R37.2@2875,2381.5
NetD9_1: D9.1 R38.2 | length 91
  Top Layer w20: R38.2@1845,2380 1847.49,2382.49 D9.1@1847.49,2470
NetD10_1: D10.1 R39.2 | length 93.3
  Top Layer w20: D10.1@798.27,2489.83 813.03,2475.07 R39.2@813.03,2402.62
NetD13_1: D13.1 R17.1 | length 68
  Top Layer w7.87: D13.1@1880.47,602.05 R17.1@1880.47,669.97
NetD14_1: D14.1 R18.1 | length 222.8
  Top Layer w10: R18.1@1881.44,748 1881.44,748.98 1912.77,780.32 2006.94,780.32 2040.29,813.66 D14.1@2040.29,849.84
NetJ5_1: J5.1 L1.2 | length 88.5
  Top Layer w7.87: J5.1@2943.18,197 2948.1,201.92 2948.1,227.87 2962.24,242 2962.24,256.74 L1.2@2977,271.5
NetJ12_4: J12.4 TP30.1 | length 658.8
  Top Layer w7.87: J12.4@2665,1581 2670.36,1581 2714.65,1536.71 3235.71,1536.71 TP30.1@3285,1586
NetJ13_2: J13.2 TP33.1 | length 186.2
  Top Layer w10: J13.2@1547,500.79 1681.21,500.79 TP33.1@1718,464
NetJ14_2: J14.2 R47.1 | length 768.5
  Top Layer w10: J14.2@886.45,178.34 886.45,114.91 901.61,99.74 1495.74,99.74 R47.1@1559,163
NetQ7_1: Q7.1 Q7.2 Q7.3 R57.1 | length 423.2
  Top Layer w40: R57.1@2667,1757.37 2819.67,1757.37 2885.22,1822.91 2945.91,1822.91 Q7.3@2958,1835 Q7.2@2958,1885 Q7.1@2958,1935
NetQ7_5: Q7.5 Q7.6 Q7.7 Q7.8 Q7.9@3107.61,1860 R55.1 | length 186.7
  Top Layer w25: R55.1@3089.5,2035 3178.08,1946.42 Q7.8@3178.08,1935 Q7.7@3178.08,1885
NetR19_1: R19.1 S1.3 | length 243
  Top Layer w10: S1.3@268,777.95 415.49,777.95 R19.1@483,710.44
NetR20_2: R20.2 S1.1 | length 231.6
  Top Layer w10: S1.1@268,577.95 446.39,577.95 R20.2@484,615.56
NetR21_1: R21.1 S2.3 | length 239.1
  Top Layer w10: S2.3@268,1205 421.44,1205 R21.1@482,1144.44
NetR23_2: R23.2 S2.1 | length 230
  Top Layer w10: S2.1@268,1005 443.44,1005 R23.2@482,1043.56
NetR24_1: R24.1 S3.3 | length 244.1
  Top Layer w10: S3.3@269,1628 403.44,1628 R24.1@481,1550.44
NetR46_1: R46.1 TP3.1 | length 157.7
  Top Layer w10: R46.1@3402.9,1886.54 3416.57,1872.86 3416.57,1854.2 3430.27,1840.5 3431.26,1840.5 3459.37,1812.39 3500.05,1812.39 TP3.1@3513.45,1799
NetR47_2: R47.2 R49.2 | length 163.8
  Top Layer w7.87: R47.2@1459,163 1459,246.17 R49.2@1516,303.17
NetR48_2: R48.2 S3.1 | length 221.5
  Top Layer w10: S3.1@269,1428 461.44,1428 R48.2@482,1448.56
NetR49_1: R49.1 R54.2 | length 134.6
  Top Layer w7.87: R54.2@1400,313.5 1440.5,313.5 1485.29,358.29 R49.1@1516,358.29
NetR52_1: R52.1 S4.3 | length 394
  Top Layer w10: S4.3@268,2067 315.5,2067 R52.1@560.5,1822
NetR53_2: R53.2 S4.1 | length 164.1
  Top Layer w10: S4.1@268,1867 313,1822 R53.2@413.5,1822
nFAULT: J9.7 R5.1 R7.2 R14.1 U1.35 | length 1776
  Top Layer w7.87: R5.1@1594,1430.36 1697.64,1430.36 1735,1393 v1(1735,1377) ; U1.35@2034.37,1623.51 2034.37,1607.96 2042.44,1599.89 2047.96,1599.89 2106.98,1540.87 2106.98,1515.8 R7.2@2077,1485.83 2048.46,1457.28 2048.46,1323.54 v1(2051,1321)
  Top Layer w10: J9.7@2304.16,1166 2491.16,1353 R14.1@2788.44,1353 ; R14.1@2785.6,1354.16 R14.1@2786.44,1355
  Bottom Layer w7.87: v1(1735,1377) 1811.39,1300.61 2030.61,1300.61 v1(2051,1321)
  Bottom Layer w10: v1(2051,1321) 2085.89,1286.11 2184.05,1286.11 2277,1193.16 2287.25,1193.16 2304.16,1176.25 J9.7@2304.16,1166
OUTA: C12.1 C15.2 C26.1 J11.1 NT1.2 Q1.3 Q4.4 R22.1 TP27.1 | length 164.8
  Top Layer w50: 2619.68,2893.5 NT1.2@2700,2893.5 2784.46,2893.5
  other v1: 2808,3766 2908,3766 3008,3766 3108,3766 2658,3866 2758,3866 2858,3866 2958,3866 3058,3866 2508,3966 2608,3966 2708,3966 2808,3966 2908,3966 2458,4066 2558,4066 2658,4066 2758,4066 2858,4066 2408,4166 2508,4166 2608,4166 2708,4166 2458,4266 2658,4266 2408,4366 2508,4366 2608,4366 2708,4366
OUTB: C13.1 C17.2 C24.1 J11.2 NT2.2 Q2.3 Q5.4 R60.1 TP28.1 | length 194.9
  Top Layer w20: NT2.2@1704.76,2894.33 NT2.2@1715.47,2894.33
  Top Layer w50: 1613.18,2894.33 NT2.2@1704.76,2894.33 ; NT2.2@1715.47,2894.33 1808.12,2894.33
  other v1: 1808,3866 1908,3866 2008,3866 2108,3866 2208,3866 2308,3866 2408,3866 2508,3866 1958,3966 2058,3966 2158,3966 2258,3966 2358,3966 2008,4066 2108,4066 2208,4066 2308,4066 2058,4166 2158,4166 2258,4166 2008,4266 2108,4266 2208,4266 2308,4266 2058,4366 2158,4366 2258,4366
OUTC: C14.1 C19.2 C25.1 J11.3 NT3.2 Q3.3 Q6.4 R75.1 TP29.1 | length 479.3
  Top Layer w20: C19.2@479.56,2884 R75.1@479.56,2937
  Top Layer w50: 552.93,2882.52 NT3.2@627.77,2882.52 777.01,2882.52 Q6.4@920,3025.51
  other v1: 1208,3866 1308,3866 1408,3866 1508,3866 1608,3866 1708,3866 1358,3966 1458,3966 1558,3966 1658,3966 1758,3966 1408,4066 1508,4066 1608,4066 1708,4066 1808,4066 1908,4066 1558,4166 1658,4166 1758,4166 1858,4166 1608,4266 1708,4266 1908,4266 1758,4366 1858,4366
POT: C36.1 J9.9 J13.4 R54.1 SW1.6 | length 1961.2
  Top Layer w7.87: SW1.6@911,578 911,531 977.54,464.46 977.54,464.14 1065.77,375.9 1302.65,375.9 1303.24,376.5 1398.82,376.5 1399.41,375.9 R54.1@1400,376.5 1400,388 1447,435 J13.4@1447,500.79
  Top Layer w10: J13.4@1447,500.79 J13.4@1456.24,491.54
  Bottom Layer w7.87: J13.4@1447,500.79 1502.27,556.06 1502.27,640.54 1632.33,770.6 2015.3,770.6 2159.87,915.17 2159.87,1121.71 J9.9@2204.16,1166