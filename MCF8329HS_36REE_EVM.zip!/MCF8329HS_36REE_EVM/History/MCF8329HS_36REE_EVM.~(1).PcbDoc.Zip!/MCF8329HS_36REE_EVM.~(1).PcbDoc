# Altium PCB MCF8329HS_36REE_EVM.~(1).PcbDoc (part 3 of 3)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 3650 x 4750 mil, 4 copper layers (Top Layer, GND Layer, Power Layer, Bottom Layer), stack 58.4 mil thick; 243 components, 121 nets, 619 pads, 914 vias.

## Via types
v1: diameter 20, hole 10, Top Layer to Bottom Layer, tented both sides, 906 vias
v2: diameter 19.68, hole 7.87, Top Layer to Bottom Layer, 8 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
PVDD: C6.1 C7.2 C18.1 C20.1 C21.2 C22.2 C23.2 C33.1 C34.1 C35.1 C44.1 J3.2 J10.1 Q1.4 Q2.4 Q3.4 R25.1 R26.1 R27.1 R55.2 TP14.1 U1.5 | length 2451.3
  Top Layer w7.87: U1.5@2069.8,1710.13 2112.4,1710.13 2147.58,1674.94 2176.89,1674.94 C7.2@2197,1654.83
  Top Layer w20: v1(3020.14,2084) 3026.5,2077.64 R55.2@3026.5,2035
  Power Layer w100: 2357,1624 2536.77,1803.77 2749.43,1803.77 3020.14,2074.48 v1(3020.14,2084) 3299,2362.86 3299,3358.84
  other v1: 2261.89,1566 2308,1566 2357.15,1566.39 2408,1566 408,3166 1408,3166 1508,3166 2508,3166 358,3266 458,3266 558,3266 658,3266 1458,3266 1558,3266 1658,3266 1758,3266 2458,3266 2558,3266 2658,3266 2758,3266 3258,3266 3358,3266 1453,3340 1511.41,3340 385,3341 443.41,3341 1566,3341 1626,3341 1684.27,3341 1736,3341 498,3342 558,3342 616.27,3342 668,3342 2480,3355 2530,3355 2580,3355 2630,3355 2680,3355 2730,3355 3208,3366 3308,3366 1454,3394 1735.03,3394 386,3395 667.03,3395 1511.41,3396.6 1566,3397 1626,3396.6 1684.27,3397 443.41,3397.6 498,3398 558,3397.6 616.27,3398 2479.88,3404.96 2529.88,3404.96 2579.88,3404.96 2629.88,3404.96 2679.88,3404.96 2729.88,3404.96 2479.88,3454.96 2529.88,3454.96 2579.88,3454.96 2629.88,3454.96 2679.88,3454.96 2729.88,3454.96 1452,3459.15 384,3460.15 1511.41,3460 1567,3460 1683.84,3460 1735.03,3460 443.41,3461 499,3461 615.84,3461 667.03,3461 1626,3461 558,3462 3258,3466 3358,3466 2479.88,3504.96 2529.88,3504.96 2579.88,3504.96 2629.88,3504.96 2679.88,3504.96 2729.88,3504.96 1626,3513.17 1684.27,3513.17 1736.57,3513 558,3514.17 616.27,3514.17 668.57,3514 1567,3515 499,3516 1512,3518 444,3519 1450.66,3519 382.66,3520 2479.88,3554.96 2529.88,3554.96 2579.88,3554.96 2629.88,3554.96 2679.88,3554.96 2729.88,3554.96 208,3566 308,3566 1308,3566 2308,3566 2408,3566 3208,3566 1511.7,3572 1567,3572 1736,3572 443.7,3573 499,3573 668,3573 1450.66,3573 1626,3573 1684.27,3573 382.66,3574 558,3574 616.27,3574 258,3666 358,3666 458,3666 558,3666 1558,3666 1658,3666 2358,3666 2458,3666 2558,3666 2658,3666 3258,3666 3358,3666 208,3766 308,3766 408,3766 508,3766 608,3766 708,3766 808,3766 908,3766 1008,3766 1608,3766 1708,3766 1808,3766 2408,3766 2508,3766 2608,3766 2708,3766 3308,3766 3180,3860.14 3230,3860.14 3280,3860.14 3330,3860.14 258,3866 358,3866 458,3866 558,3866 658,3866 758,3866 858,3866 958,3866 1058,3866 3358,3866 3130,3910.14 3180,3910.14 3230,3910.14 3280,3910.14 3330,3910.14 3080,3960.14 3130,3960.14 3180,3960.14 3330,3960.14 408,3966 508,3966 608,3966 1108,3966 3208,3966 3080,4010.14 3130,4010.14 3180,4010.14 3330,4010.14 3080,4060.14 3130,4060.14 3180,4060.14 3230,4060.14 3280,4060.14 3330,4060.14 958,4066 1058,4066 1158,4066 1258,4066 2958,4066 3358,4066 3080,4110.14 3130,4110.14 3180,4110.14 3230,4110.14 3280,4110.14 3330,4110.14 1108,4166 1208,4166 1308,4166 1158,4266 1358,4266 1208,4366 1308,4366 1408,4366
SCL: R4.1 R11.2 U1.30 | length 848.4
  Top Layer w7.87: R4.1@1306,1430.36 1388.88,1513.24 1733.76,1513.24 v1(1734,1513) ; U1.30@1955.63,1623.51 1955.63,1607.96 1951.57,1603.9 1951.57,1578.13 R11.2@1937.29,1563.85 1937.29,1563.71 1967,1534 1968,1535 v1(1969,1535)
  Bottom Layer w7.87: v1(1734,1513) 1740.19,1506.81 1743.03,1506.81 1765.85,1484 1924,1484 1972,1532 v1(1969,1535)
SDA: R2.1 R12.2 U1.29 | length 818.1
  Top Layer w7.87: R2.1@1234,1430.36 1255.21,1430.36 1365.85,1541 v1(1734,1541) ; v1(1832,1517) 1878.85,1563.85 R12.2@1884.29,1563.85 1884.29,1567.92 U1.29@1939.88,1623.51
  Bottom Layer w7.87: v1(1734,1541) 1736.85,1541 1772.85,1505 1820,1505 v1(1832,1517)
SHA: C8.2 J4.3 NT1.1 U1.10 | length 1478.5
  Top Layer w7.87: U1.10@2069.8,1788.87 2089.98,1809.05 2186.59,1809.05 2227.54,1850 2384.38,1850 2433.38,1899 C8.2@2475.44,1899
  Top Layer w25: C8.2@2475.44,1899 2475.44,1905.18 2529.27,1959 2563,1959 J4.3@2634,2030 ; v1(2700,2545) NT1.1@2700,2813.5
  GND Layer w25: J4.3@2634,2030 2700,2096 v1(2700,2545)
SHB: C9.1 J4.7 NT2.1 U1.14 | length 1364.4
  Top Layer w7.87: U1.14@2002.87,1812.49 2002.87,1841.08 2063.92,1902.13 C9.1@2120,1902.13
  Top Layer w25: v1(1703.5,2544.5) 1703.5,2670 1704.76,2671.26 NT2.1@1704.76,2814.33 ; C9.1@2120,1902.13 2120,1920 J4.7@2235,2035
  GND Layer w25: v1(1703.5,2544.5) 2213,2035 J4.7@2235,2035
SHC: C10.1 J4.11 NT3.1 U1.18 | length 1855.3
  Top Layer w7.87: C10.1@1852.44,1901 1852.44,1849.56 1889.51,1812.49 U1.18@1939.88,1812.49
  Top Layer w25: NT3.1@627.77,2802.52 627.77,2743.23 v1(708,2663) ; J4.11@1835,2035 1835,1960 1852.44,1942.56 C10.1@1852.44,1901
  GND Layer w25: v1(708,2663) 1207,2663 J4.11@1835,2035
SN: C31.2 C32.1 R45.1 TP39.1 U1.23 | length 1041.7
  Top Layer w7.87: R45.1@963,1826.44 963,1815 986,1792 1276.73,1792 1320.47,1748.26 1374.41,1748.26 1433.67,1689 TP39.1@1454.87,1689 1576.56,1689 C31.2@1587,1699.44 1666.12,1699.44 C32.1@1667,1698.56 1694.31,1725.87 1739.02,1725.87 1744.88,1731.74 1862.61,1731.74 1868.47,1725.87 U1.23@1920.2,1725.87
SP: C30.2 C31.1 R43.1 TP11.1 U1.22 | length 996.4
  Top Layer w7.87: R43.1@1020,1826.44 1034.29,1826.44 1047.73,1813 1278,1813 1326.99,1764.01 1373.11,1764.01 1419.1,1810 TP11.1@1454.87,1810 1531.56,1810 C31.1@1587,1754.56 1645.12,1754.56 C30.2@1667,1776.44 1701.82,1741.62 1732.49,1741.62 1738.36,1747.49 1869.13,1747.49 1875,1741.62 U1.22@1920.2,1741.62
SPEED/WAKE: J9.25 R51.2 U1.27 | length 1031.5
  Top Layer w7.87: v1(1872,1637) 1897.88,1662.88 U1.27@1920.2,1662.88
  Top Layer w10: J9.25@1404.16,1166 1414.68,1176.52 1449.55,1176.52 1571.33,1298.3 1582.8,1298.3 R51.2@1596.5,1312
  Bottom Layer w7.87: J9.25@1404.16,1166 1404.16,1263.01 1704.15,1563 1798,1563 v1(1872,1637)
SPEED_IN: J13.1 J13.3 J13.5 SW1.1 | length 502.4
  Top Layer w10: SW1.1@1111,478 1224.21,478 J13.5@1347,600.79 J13.3@1447,600.79 ; J13.3@1436,611.79 J13.3@1447,600.79 ; J13.1@1547,600.79 J13.3@1447,600.79
SPEED_WAKE: J9.26 SW1.2 | length 970.6
  Top Layer w7.87: SW1.2@1011,478 951,538 951,848.86 1069.24,967.09 1359.53,967.09 1404.16,1011.72 J9.26@1404.16,1066
VREG: C37.2 C38.1 J12.1 J12.3 J12.5 U1.2 | length 1160.8
  Top Layer w7.87: U1.2@2069.8,1662.88 2085.35,1662.88 2100.19,1648.05 v1(2100.19,1610)
  Top Layer w25: J12.3@2665,1481 J12.5@2765,1481
  Top Layer w30: C38.1@2473,1696.11 2473,1541 2533,1481 J12.1@2565,1481 J12.3@2665,1481
  Top Layer w40: C38.1@2473,1696.11 C37.2@2569,1696.11
  Power Layer w25: v1(2100.19,1610) 2228.19,1482 2564,1482 J12.1@2565,1481
VREG_EXT_FET: J12.6 R57.2 | length 172.7
  Top Layer w7.87: R57.2@2667,1694.38 2667,1647 2733,1581 J12.6@2765,1581
WAKE: S4.2 SW1.3 | length 2183.8
  Top Layer w7.87: S4.2@268,1967 214,1913 214,520 256,478 SW1.3@911,478
pads on no net: FID1.1 FID2.1 FID3.1 H1.0 H2.0 H3.0 H4.0 H5.1 H6.1 H7.1 H8.1 J9.3 J9.4 J9.13 J9.14 J9.17 J9.18 J9.19 J9.20 Q7.9@3053.08,1802.91 Q7.9@3053.08,1860 Q7.9@3053.08,1917.09 Q7.9@3089.69,1860 Q7.9@3123.16,1802.91 Q7.9@3123.16,1860 Q7.9@3123.16,1917.09 SH-J1.0 SH-J2.0 SH-J3.0 SH-J4.0 SH-J5.0 SH-J6.0 SH-J7.0 SH-J8.0 SH-J10.0 SH-J11.0 SH-J12.0 SH-J13.0 SH-J14.0 SH-J15.0 SH-J16.0 SH-J17.0 SH-J18.0 SH-J19.0 SH-J20.0 SH-J21.0 SH-J22.0 SH-J23.0 SH-J24.0 SH-J25.0 U2.6 U2.9 U3.2 U3.3 U3.6 U3.8 U3.9 U3.10 U3.11 U3.12 U3.13 U3.14 U3.19 U3.22 U3.23 U3.24 U3.27 U3.28 U4.1 U5.1 U5.2 U5.3 U5.10 U5.11 U5.14 U5.15 U5.16 U5.17 U5.18 U5.19 U5.20 U5.21 U5.22 U5.25 U5.26 U5.30 U5.31 U5.32 U5.33 U5.34 U5.35 U5.36 U5.37 U5.38 U5.39 U5.40 U5.41 U5.45 U5.46 U5.47
copper on no net: | length 14.1
  Top Layer w10: 1804.16,1166 1811.11,1166 1815.25,1170.14 ; 2189.42,432.68 2190.32,433.58

## Polygon pours and split planes (outlines as drawn)
GND on Top Layer "TOP_LAYER_GND_P050" (solid, remove dead copper, pour order 50): 0,4750 3650,4750 3650,0 0,0
no net on Top Layer "TOP_LAYER_NONET_P099" (solid, pour order 99): 1584.87,968.89 1585.46,969.48 1620.73,969.48 1620.73,887.88 1623.03,885.58 1581.16,885.58 1581.16,948.05 1572.16,957.04 1573.52,958.4 1573.52,967.67 1574.74,968.89 1583.25,968.89
no net on Top Layer "TOP_LAYER_NONET_P098" (solid, pour order 98): 2597.32,395.35 2471.21,395.35 2471.21,344.77 2470.48,344.03 2597.5,344.03 2597.5,395.18
no net on Top Layer "TOP_LAYER_NONET_P097" (solid, pour order 97): 2469.51,397.06 2471.21,395.35 2597.32,395.35 2599.03,397.06 2599.03,345.56 2595.97,342.5 2468.95,342.5 2468.95,396.5 2469.51,397.06 2599.03,397.06 2599.03,345.56 2595.97,342.5 2468.95,342.5 2468.95,396.5
PVDD on Top Layer "TOP_LAYER_PVDD_P048" (solid, remove dead copper, pour order 48): 2176.39,1682.98 2447.09,1682.98 2447.09,1531.44 2230.06,1531.44 2176.39,1585.11
LSS on Top Layer "TOP_LAYER_LSS_P034" (solid, remove dead copper, pour order 34): 930,3000 3331.96,3000 3405,2926.96 3405,2741.26 3310,2646.26 3310,1970 1456.96,1967 1440.02,1936 1279.35,1936 1015.34,1936 1015.02,2015.84 1015.34,2205 903.27,2540 680.94,2705 680,2814.68 970,2931.8
PVDD on Top Layer "TOP_LAYER_PVDD_P008" (solid, remove dead copper, pour order 8): 710.13,3576.54 747.36,3613.77 747.36,3740.44 1015.44,3740.44 1450,4175 1450,4412.44 1412.44,4450 1174.2,4450 1124.2,4400 1124.2,4399.2 1100,4375 1100,4270 908,4078 613,4078 487.4,4000.4 301.85,3996.57 150.67,3845.39 150.67,3475 313.11,3475 313.11,3222.43 207.48,3155.59 207.48,3037.91 325.15,3037.91 653.18,3222.43 710.13,3279.38
OUTA on Top Layer "TOP_LAYER_OUTA_P006" (solid, remove dead copper, pour order 6): 2762.91,2853.5 2566,2853.5 2566,2952.97 2602.4,2989.37 2602.4,3215.17 2612.46,3225.23 2816.93,3225.23 2816.93,3461.89 2830.04,3475 2917.56,3475 2917.56,3715.16 2882.72,3750 2787.91,3750 2758.75,3788.66 2626.5,3788.66 2381.1,4059.1 2381.1,4450 2656.8,4450 2760.94,4345.85 2760.94,4184.69 3175,3770.63 3175,3252.2 3224.2,3203 3375,3203 3375,3125 3350,3100 3199.98,3100 3199.98,2804.88 3170.1,2775 2762.91,2775
OUTB on Top Layer "TOP_LAYER_OUTB_P004" (solid, remove dead copper, pour order 4): 1987.87,4078.28 1709.8,3800.2 1890.66,3800.2 1929.13,3761.73 1929.13,3475 1832.87,3475 1806.68,3448.8 1806.68,3189.49 1556.8,3189.49 1556.8,2947.42 1535,2937.94 1535,2840.23 1580.27,2840.23 1580.27,2862.2 1769.88,2862.2 1778.58,2853.5 1778.58,2789.37 2156.8,2789.37 2201.02,2833.6 2201.02,3089.49 2322.64,3089.49 2322.64,3217.14 2325,3219.5 2211.32,3219.5 2211.32,3622.36 2315,3726.04 2319.31,3790 2615.89,3790 2365,4058.16 2365,4450 1988.81,4450 1987.87,4449.99
OUTC on Top Layer "TOP_LAYER_OUTC_P002" (solid, remove dead copper, pour order 2): 999.99,3731.17 874.65,3731.17 868.48,3725 868.48,3450.2 736.93,3450 747.36,3439.57 747.36,3225 579.45,3225 465.1,3110.65 465.1,2899.65 519.33,2845.42 683.31,2845.42 703.72,2825 1121.97,2825 1121.97,3021.97 1137.91,3037.91 1265.99,3037.91 1265.99,3134.01 1200,3200 1200,3575 1275,3650 1410,3650 1559.32,3799.32 1690,3799.32 1964.76,4075 1964.74,4450 1745.5,4450 1719,4450
GLB_FET on Top Layer "TOP_LAYER_GLB_FET_P026" (solid, remove dead copper, pour order 26): 1903,2364.69 1904,2363.69 1903,2275.62 2175,2275.62 2175,2502.27 1975.47,2502.27 1926.42,2551.32 1926.42,2695.51 1919.81,2702.12 1868.41,2702.12 1868.31,2520 1903,2520
GHC_FET on Top Layer "TOP_LAYER_GHC_FET_P018" (solid, remove dead copper, pour order 18): 350,3135.78 350,2931.95 323.38,2905.33 323.38,2807.91 459.69,2807.91 467.6,2800 467.6,2650.51 500,2618.11 572.34,2618.11 572.34,2794.36 457.72,2908.98 457.72,3135.78
PVDD on Top Layer "TOP_LAYER_PVDD_P046" (solid, remove dead copper, pour order 46): 2890,4135 3356.77,4135 3375,4116.77 3375,3260.23 3345,3250.72 3150,3250.72 3150,3740 2890,4000
PVDD on Top Layer "TOP_LAYER_PVDD_P012" (solid, remove dead copper, pour order 12): 2803.49,3252.2 2803.49,3706.78 2725.26,3785 2291.73,3785 2291.73,3673.85 2244.09,3626.21 2235,3626.21 2235,3489.41 2250,3474.41 2422.56,3474.41 2435.08,3461.89 2435.08,3192.17 2350,3107.09 2350,3016.49 2360.98,3005.51 2437.68,3005.51 2450,3017.83 2450,3107.09 2564.4,3150 2592.91,3250 2602.4,3250
PVDD on Top Layer "TOP_LAYER_PVDD_P010" (solid, remove dead copper, pour order 10): 1414.37,3625 1574.37,3785 1827.38,3785 1827.38,3728.76 1801.38,3702.76 1801.38,3619.7 1775.57,3593.9 1775.57,3225 1559.71,3225 1425,2989.45 1300,2989.45 1300,3087.09 1382.58,3144.19 1411.06,3217.14 1411.06,3439.57 1400.43,3450.2 1225,3450.2 1225,3562.4 1287.6,3625
GND on Top Layer "TOP_LAYER_GND_P016" (solid, remove dead copper, pour order 16): 1169,3474.41 1434.08,3474.41 1437.58,3470.91 1437.58,3145.12 1173.88,3145.12 1169,3150
GND on Top Layer "TOP_LAYER_GND_P014" (solid, remove dead copper, pour order 14): 2184.35,3484.49 2443.8,3484.49 2462.2,3466.09 2462.2,3189.49 2459.53,3192.17 2184.35,3192.17
GLA_FET on Top Layer "TOP_LAYER_GLA_FET_P028" (solid, remove dead copper, pour order 28): 2875,2700 2922.73,2700 2927.73,2695 2935.94,2520 3060.5,2510 3060.5,2350 2920,2350 2915,2355 2915,2489.83 2875,2529.83
GLC_FET on Top Layer "TOP_LAYER_GLC_FET_P024" (solid, remove dead copper, pour order 24): 790,2715 855,2715 855,2560 907.42,2507.58 1024.72,2507.58 1024.72,2440.28 1085,2380 1080,2375 850,2375 850,2485.33 815,2520.33 790,2520.33
GHA_FET on Top Layer "TOP_LAYER_GHA_FET_P022" (solid, remove dead copper, pour order 22): 2445,3131.47 2575,3131.47 2575,2989 2546,2960 2546,2830.8 2635,2741.8 2635,2605 2564.4,2605 2564.4,2738.55 2522.95,2780 2409.59,2780 2409.59,2866.92 2445,2902.33
GHB_FET on Top Layer "TOP_LAYER_GHB_FET_P020" (solid, remove dead copper, pour order 20): 1445,3133.13 1447.66,3135.78 1565,3135.78 1565,2955 1522.44,2955 1522.44,2857.54 1625,2754.98 1625,2622.68 1617.32,2615 1533.11,2615 1530,2618.11 1530,2786.78 1526.78,2790 1380,2790 1380,2852.42 1445,2917.42
OUTC on Power Layer "POWER_LAYER_OUTC_P111" (solid, remove dead copper, pour order 111): 1747.72,4449.99 1100.2,3802.46 1100.2,3801.8 1694.11,3801.15 1968.87,4076.82 1968.87,4449.99
OUTB on Power Layer "POWER_LAYER_OUTB_P109" (solid, remove dead copper, pour order 109): 2365,4039.21 2604,3800.2 2319,3800.2 1709.8,3800.2 1709.8,3803.33 1988.34,4081.87 1988.34,4450 2365,4450
OUTA on Power Layer "POWER_LAYER_OUTA_P107" (solid, remove dead copper, pour order 107): 2393.78,4038.53 2639.17,3793.14 2771.43,3793.14 2800.59,3754.48 3208.31,3754.48 2773.62,4189.17 2773.62,4350.33 2669.47,4454.48 2393.78,4454.48
GND on Power Layer "POWER_LAYER_GND_P068" (solid, remove dead copper, pour order 72): 0,4750 3650,4750 3650,0 0,0
3V3_MCU on Power Layer "Power Layer-3V3_MCU" (solid, pour order 66): 3418,1593 2995,1170 2995,841 2996,840 2969,813 1824.2,813 1824.2,486.2 1668,330 1668,183 1671,186 2276,186 2276,60 2379,60 2379,454 1950,454 1950,735 2981,735 3089,843 3089,1097 3185,1097 3248,1160 3248,1289 3454,1495 3563,1495 3563,1593
PVDD on Power Layer "POWER_LAYER_PVDD_P062" (solid, remove dead copper, pour order 62): 1412.44,4450 1450,4412.44 1450,4198.1 1051.9,3800 3141,3800 2890,4091.68 2890,4135 3356.77,4135 3375,4116.77 3374,3800 3386,3788 3386,2845.5 3277.16,2736.66 416.21,2736.66 313.11,2839.76 313.11,3475 150.67,3475 150.67,3845.39 301.85,3996.57 561,3996.57 589.42,4025 855,4025 1100,4270 1100,4375.8 1174.2,4450
LSS on Power Layer "POWER_LAYER_LSS_P070" (solid, remove dead copper, pour order 70): 680.94,2705 680.94,2694.22 1015.34,2359.83 1015.34,2205 1015.02,2015.84 1015.34,1936 1279.35,1936 1325,1828 1381,1828 1432.39,1922.04 3265,1925 3310,1970 3310,2646.26 3405,2741.26 3405,2926.96 3331.96,3000 930,3000 970,2931.8 680,2814.68
PVDD on Power Layer "POWER_LAYER_PVDD_P052" (solid, remove dead copper, pour order 52): 2146,1700 2485,1700 2485,1554.34 2248.66,1554.34 2174.51,1628.49 2146,1628.49
5V_USB on Power Layer "POWER_LAYER_5V_USB_P060" (solid, pour order 60): 3100,452 3100,300 3099,299 3098,300 2611,300 2611,452 2614,452
GND on GND Layer "GND_LAYER_GND_P066" (solid, remove dead copper, pour order 82): 0,4750 3650,4750 3650,0 0,0
LSS on GND Layer "GND_LAYER_LSS_P080" (solid, remove dead copper, pour order 80): 930,3000 3331.96,3000 3405,2926.96 3405,2741.26 3310,2646.26 3310,1970 3265,1925 1432.39,1922.04 1381,1828 1325,1828 1279.35,1936 1015.34,1936 1015.02,2015.84 1015.34,2205 903.27,2540 680.94,2705 680,2814.68 970,2931.8
OUTA on GND Layer "GND_LAYER_OUTA_P078" (solid, remove dead copper, pour order 78): 2393.78,4038.53 2639.17,3793.14 2771.43,3793.14 2800.59,3754.48 3208.31,3754.48 2773.62,4189.17 2773.62,4350.33 2669.47,4454.48 2393.78,4454.48
OUTB on GND Layer "GND_LAYER_OUTB_P076" (solid, remove dead copper, pour order 76): 2365,4039.21 2604,3800.2 2319,3800.2 1709.8,3800.2 1709.8,3803.33 1988.34,4081.87 1988.34,4450 2365,4450
OUTC on GND Layer "GND_LAYER_OUTC_P074" (solid, remove dead copper, pour order 74): 1747.72,4449.99 1100.2,3802.46 1100.2,3801.8 1694.11,3801.15 1968.87,4076.82 1968.87,4449.99
GND on Bottom Layer "BOTTOM_LAYER_GND_P096" (solid, remove dead copper, pour order 96): -5.37,4724.31 3644.63,4724.31 3644.63,-25.69 -5.37,-25.69
LSS on Bottom Layer "BOTTOM_LAYER_LSS_P094" (solid, remove dead copper, pour order 94): 710,2776.94 1045.34,2441.61 1045.34,2276 1045.02,2086.84 1045.34,2007 1309.35,2007 1355,1899 1411,1899 1462.39,1993.04 3295,1996 3340,2041 3340,2717.26 3435,2812.26 3435,2997.96 3361.96,3071 895.32,3071 710,2885.68
OUTA on Bottom Layer "BOTTOM_LAYER_OUTA_P088" (solid, remove dead copper, pour order 88): 3208.31,3750 2800.59,3750 2771.43,3788.66 2639.17,3788.66 2393.78,4059.1 2393.78,4450 2669.47,4450 2773.62,4345.85 2773.62,4184.69
OUTB on Bottom Layer "BOTTOM_LAYER_OUTB_P086" (solid, remove dead copper, pour order 86): 2325,3795 1686,3795 1905.06,4019.8 1988.81,4103.55 1994.23,4444.8 2321,4444.8 2371,4444.8 2371,4052.95 2610,3795
OUTC on Bottom Layer "BOTTOM_LAYER_OUTC_P084" (solid, remove dead copper, pour order 84): 1081.11,3801.82 1749.61,4451.82 1968.87,4449.99 1968.87,4206.59 1968.87,4076.82 1694.11,3801.15

## Keep-outs
Keep-Out Layer:
  text ".Layer_Name" at 577,-858.49 h60

## Other copper
Top Layer:
  pour cut-out: 2469.51,397.06 2599.03,397.06 2599.03,345.56 2595.97,342.5 2468.94,342.5 2468.94,397.62 2469.51,397.06 2599.03,397.06 2599.03,345.56 2595.97,342.5 2468.94,342.5 2468.94,397.62
  pour cut-out: 906.09,2218 906.09,1838 979.71,1838 979.71,2218
  text ".Layer_Name" at 723.9,-872.69 h60
GND Layer:
  text ".Layer_Name" at 742.8,-863.19 h60
Power Layer:
  text ".Layer_Name" at 738.1,-872.69 h60
Bottom Layer:
  text ".Layer_Name" at 728.6,-872.69 h60

## Silkscreen, mask and mechanical layers (free items; w line width, h text height)
Top Overlay:
  circle w8: c3594.36,2202.97 r4.91
  circle w8: c3565.66,1641.58 r4.91
  circle w8: c3570.66,836.58 r4.91
  circle w8: c2430.42,197.66 r4.91
  circle w8: c987.87,251 r4.91
  lines w5: 1526.33,992.45 1535.1,1001.23 1592.31,1001.23 1601.09,1010
  lines w6: 736.45,148.03 736.45,227.84 ; 736.45,208.66 736.45,128.34 1036.45,128.34 1036.45,228.34 736.95,228.34 ; 3462.69,1693 3542.5,1693 ; 3467.69,888 3547.5,888 ; 3491.39,2254.39 3571.21,2254.39 ; 3523.31,1693 3443,1693 3443,1393 3543,1393 3543,1692.5 ; 3528.31,888 3448,888 3448,588 3548,588 3548,887.5 ; 3552.02,2254.39 3471.71,2254.39 3471.71,1954.39 3571.71,1954.39 3571.71,2253.89 ; 2478.99,75.44 2479,75.44 ; 2478.99,75.44 2478.55,75 2079,75 2079,175 2088.84,175 2479,175 2479,75.44
  lines w8: 83.09,2227 390,2227 ; 86,2360 390,2360 ; 103,2269.5 115.5,2254.5 ; 103,2407 115.5,2422 ; 115.5,2309.5 115.5,2254.5 ; 115.5,2367 115.5,2422 ; 128,2269.5 115.5,2254.5 ; 128,2407 115.5,2422 ; 145.5,2167 145.5,2523 ; 210.5,2167 210.5,2525 ; 267.81,2168.82 268.05,2523 ; 329,2167 388,2167 390,2169 390,2526 ; 329.92,2526 390.08,2526 ; 1183,1349.2 1183,1521 1625,1521 ; 1183.2,1349 1627,1349 1627,1519 ; 83,2167 83,2526 328,2526 328,2167 83,2167
  text "30A Abs MAX" at 425,4292 h40
  text "GND" at 845.18,4127.32 h40
  text "PVDD" at 1220.2,4126.84 h40
  text "OUTC" at 1714.48,4127.32 h40
  text "OUTB" at 2108.31,4126.82 h40
  text "OUTA" at 2499.79,4126.82 h40
  text "'.PRJ_Number'" at 1621.5,4007.59 h100
  text "Rev 1.0" at 2008,3921.91 h60
  text "MD121-001" at 102.11,3374.61 h80 r90
  text "ON" at 314,2414 h40 r90
  text "ACB" at 254,2398 h40 r90
  text "RUN" at 375,2391 h40 r90
  text "SLEEP" at 193,2373 h40 r90
  text "OFF" at 313,2248 h40 r90
  text "ABC" at 253,2246 h40 r90
  text "BRK" at 374,2243 h40 r90
  text "WAKE" at 194,2239 h40 r90
  text "Switches" at 65.5,2197 h40 r90
  text "1" at 371,2191 h40 r90
  text "S" at 128,2187 h40 r90
  text "3" at 250,2187 h40 r90
  text "4" at 192,2186 h40 r90
  text "2" at 312,2185 h40 r90
  text "SHC" at 1823.17,2097 h40 r90
  text "LSS" at 1544.29,2095 h40 r90
  text "GLC" at 1645.55,2095 h40 r90
  text "SHB" at 2230.44,2095 h40 r90
  text "BSTB" at 2330,2095 h40 r90
  text "GLA" at 2430,2095 h40 r90
  text "GHA" at 2536,2095 h40 r90
  text "BSTA" at 2732,2095 h40 r90
  text "GHC" at 1721.17,2094 h40 r90
  text "BSTC" at 1929.17,2094 h40 r90
  text "GLB" at 2042.17,2094 h40 r90
  text "GHB" at 2137.17,2094 h40 r90
  text "SHA" at 2629,2094 h40 r90
  text "GND" at 2854.17,2094 h40 r90
  text "3V3EXT" at 3332,1644 h30
  text "HW Variant resistors" at 1268.86,1543.75 h40
  text "3V3_MCU" at 3314.8,1516.5 h30
  text "nFAULT" at 2866,1440 h40 r90
  text "3V3COM" at 3328.67,1426.01 h30
  text "NC" at 2015.09,1234.66 h40 r45
  text "NC" at 2110.75,1234.66 h40 r45
  text "NC" at 2215.57,1234.66 h40 r45
  text "GND" at 2615.38,1234.66 h40 r45
  text "DIR" at 1196,1232.84 h40 r45
  text "DRVOFF" at 1079.58,1231.09 h40 r45
  text "NC" at 2526.67,1230.96 h40 r45
  text "NC" at 1697.13,1229.98 h40 r45
  text "NC" at 1796.92,1229.98 h40 r45
  text "DAC/SPEED" at 1912.77,1229.57 h40 r45
  text "FGOUT" at 2419.73,1229.57 h40 r45
  text "BRAKE" at 1296.5,1229.21 h40 r45
  text "nFAULT" at 2319.64,1225.88 h40 r45
  text "SCL" at 1608.68,1222.62 h40 r45
  text "SDA" at 1507.84,1221.19 h40 r45
  text "SPD/ / WAKE" at 1419.1,1217.51 h40 r45
  text "NC" at 1971.01,963.27 h40 r45
  text "NC" at 1673.86,957.72 h40 r45
  text "NC" at 2169.73,958.4 h40 r45
  text "NC" at 1770.89,954.04 h40 r45
  text "NC" at 2475.15,951.03 h40 r45
  text "GND" at 2561.74,934.36 h40 r45
  text "DIR_SW" at 1112.76,889.7 h40 r45
  text "DAC/SPEED" at 1829.91,884.66 h30 r45
  text "LVL_SDA" at 1373.86,883.88 h40 r45
  text "LVL_SCL" at 1410.75,870 h40 r45
  text "LVL_AVDD" at 1985.61,860.61 h40 r45
  text "BRAKE_SW" at 1166.5,847.89 h40 r45
  text "LVL_FGOUT" at 2271.85,840.08 h40 r45
  text "5V_EXT" at 3310.22,831.56 h40
  text "DRVOFF_SW" at 981.97,830.81 h40 r45
  text "LVL_nFAULT" at 2154.39,830.33 h40 r45
  text "SPEED_WAKE" at 1235.4,810.09 h40 r45
  text "5VCC" at 3349.18,722.48 h40
  text "5V_USB" at 3305.33,626.57 h40
  text "3.3V" at 2298,183 h40
  text "SBWTCK" at 2056,181 h40 r1.48
  text "GND" at 2405,43 h40
  text "SBWTDIO" at 2170.47,40 h40 r0.36
  text ".Layer_Name" at 577,-858.49 h40
Bottom Overlay:
  text ".Layer_Name" at 577,-858.49 h60
Top Paste:
  text ".Layer_Name" at 577,-858.49 h60
Bottom Paste:
  text ".Layer_Name" at 577,-858.49 h60
Top Solder:
  text ".Layer_Name" at 577,-858.49 h60
  text ".Layer_Name" at 577,-858.49 h60
Solder Side:
  text ".Layer_Name" at 577,-858.49 h60
Drill Guide:
  text ".Layer_Name" at 577,-858.49 h60
M1 Board Outline:
  the board outline again, w10
  text ".Layer_Name" at 577,-858.49 h60
M2 Board Dimensions:
  rectangle: 0,-275 125,-150
  rectangle: 125,-400 500,-275
  lines w7: 0,-275 1000,-275 ; 125,-400 125,-150 ; 250,-400 250,-150 ; 500,-400 500,-150 ; 750,-400 750,-150 ; 0,-400 1000,-400 1000,-150 0,-150 0,-400
  text ".Layer_Name" at 577,-858.49 h60
M3 3D STEP Top:
  text ".Layer_Name" at 577,-858.49 h60
M4 3D STEP Bottom:
  text ".Layer_Name" at 577,-858.49 h60
M5 Assembly Top:
  lines w6: 3547.5,888 3548,887.5 ; 3448,888 3448,888
  lines w10: -292,-930.17 6308,-930.17 ; -292,-726.83 6310,-726.83 ; -292,-523.5 -292,-1133.5 3713,-1133.5 6310,-1133.5 6310,-523.5 -291.5,-523.5 -291.5,-1133.5 1284,-1133.5 ; 2173,-1133.5 2173,-523.5 ; 3440,-726.83 3440,-523.5 ; 4280,-726.83 4280,-523.5 ; 4902,-1140 4902,-937.17
  text "COMPONENTS MARKED 'DNP' SHOULD NOT BE POPULATED." at 1153.5,-318.5 h60
  text "ASSEMBLY VARIANT:" at 1153,-434 h60
  text ".VariantName" at 2189,-434 h60
  text "BOARD #:" at 2190.7,-610.1 h60
  text "PCB VIEWED FROM TOP SIDE" at -228.5,-655.67 h60
  text "REV:" at 3638,-655.67 h60
  text ".PCB_Rev" at 3929.5,-655.67 h60
  text "SVN REV:" at 4476,-655.67 h60
  text ".VersionControl_RevNumber" at 4982,-655.67 h60
  text ".PRJ_Number" at 2196.6,-698.3 h60
  text "TID #:" at 2248,-859 h60
  text ".TID" at 2793.5,-859 h60
  text "PLOT NAME =" at -228.5,-1064.34 h60
  text ".plot_File_Name" at 577,-1064.34 h60
  text "GENERATED    :" at 2250,-1064.34 h60
  text ".Print_Date" at 3119.5,-1064.34 h60
  text ".Print_Time" at 3848.5,-1064.34 h60
  text "TEXAS INSTRUMENTS" at 5113,-1064.34 h60
M6 Assembly Bottom:
  lines w10: -292.5,-727.33 6309.5,-727.33 ; -290.5,-930.67 6309.5,-930.67 ; 1115.5,-1140.5 1115.5,-937.67 ; 1737.5,-727.33 1737.5,-524 ; 2577.5,-727.33 2577.5,-524 ; 3844.5,-1134 3844.5,-524 ; 4733.5,-1134 6309,-1134 6309,-524 -292.5,-524 -292.5,-1134 2304.5,-1134 6309.5,-1134 6309.5,-524
  text "COMPONENTS MARKED 'DNP' SHOULD NOT BE POPULATED." at 6102,-318 h60
  text ".VariantName" at 5058,-434 h60
  text "ASSEMBLY VARIANT:" at 6097,-434 h60
  text "BOARD #:" at 3815.8,-616.9 h60
  text ".VersionControl_RevNumber" at 1035.5,-656.17 h60
  text "SVN REV:" at 1541.5,-656.17 h60
  text ".PCB_Rev" at 2088,-656.17 h60
  text "REV:" at 2379.5,-656.17 h60
  text "PCB VIEWED FROM BOTTOM SIDE" at 6246,-656.17 h60
  text ".PRJ_Number" at 3797.8,-703.4 h60
  text ".TID" at 3224,-859.5 h60
  text "TID #:" at 3769.5,-859.5 h60
  text ".Layer_Name" at 5016.2,-871.5 h60
  text "TEXAS INSTRUMENTS" at 904.5,-1064.84 h60
  text ".Print_Time" at 2169,-1064.84 h60
  text ".Print_Date" at 2898,-1064.84 h60
  text "GENERATED    :" at 3767.5,-1064.84 h60
  text ".plot_File_Name" at 5440.5,-1064.84 h60
  text "PLOT NAME =" at 6246,-1064.84 h60
M9 Title Sheet:
  drawing of 57 lines, arcs and shapes, not listed
  text "1" at 739.84,8036.5 h70
  text "2" at 3235.5,8036.5 h70
  text "3" at 5724.84,8036.5 h70
  text "4" at 8231.51,8036.5 h70
  text "5" at 10730.5,8036.5 h70
  text "6" at 13235.5,8036.5 h70
  text "A" at -416.5,6893.5 h70
  text "A" at 14383.5,6893.5 h70
  text "B" at -416.5,4513.5 h70
  text "B" at 14383.5,4513.5 h70
  text "C" at -416.5,2138.5 h70
  text "C" at 14383.5,2138.5 h70
  text "PROJECT TITLE:" at 11343.5,277.5 h45
  text ".PRJ_Title" at 11393.5,144.17 h70
  text "DESIGNED FOR:" at 11343.5,-23.5 h45
  text ".PRJ_Customer" at 11393.5,-163.5 h70
  text "D" at -416.5,-231.5 h70
  text "D" at 14383.5,-231.5 h70
  text "FILE NAME:" at 11343.5,-323.5 h45
  text ".PCB_File_Name_No_Path" at 11393.5,-443.5 h70
  text "Texas Instruments (TI) and/or its licensors do not warrant the accuracy or completeness of this specification" at 6374,-605.34 h45
  text "ENGINEER:" at 11343.5,-613.5 h45
  text "LAYOUT BY:" at 12848.5,-613.5 h45
  text "or any information contained therein. TI and/or its licensors do not warrant that this design will meet" at 6329.01,-718 h45
  text ".PRJ_Engineer" at 11393.5,-768.49 h70
  text ".PCB_Layout" at 12899,-768.49 h70
  text "the specifications, will be suitable for your application or fit for any particular purpose, or will operate in" at 6329.01,-830.67 h45
  text ".Layer_Name" at 577,-858.49 h60
  text "ALTIUM DESIGNER VERSION:" at 12848.5,-923.5 h45
  text "an implementation. TI and/or its licensors do not warrant that the design is production worthy. You should" at 6329.01,-943.33 h45
  text "completely validate and test your design implementation to confirm the system functionality for your application." at 6374,-1056 h45
  text ".print_Scale" at 11393.5,-1056.83 h70
  text ".Application_BuildNumber" at 12899,-1056.83 h70
  text "1" at 739.84,-1263.5 h70
  text "2" at 3235.5,-1263.5 h70
  text "3" at 5724.84,-1263.5 h70
  text "4" at 8231.51,-1263.5 h70
  text "5" at 10730.5,-1263.5 h70
  text "6" at 13235.5,-1263.5 h70
M10 Fab Notes:
  drawing of 189 lines, arcs and shapes, not listed
  text "DESIGN INFORMATION" at 12382.02,6356.17 h60
  text "MIN. TRACK WIDTH:" at 11737.46,6224.05 h60
  text "8" at 12833.7,6224.05 h60
  text "MIL" at 12988.46,6224.05 h60
  text "MIN. CLEARANCE:" at 11737.46,6099.92 h60
  text "0.2" at 12773.7,6099.93 h60
  text "mm" at 12988.46,6099.92 h60
  text "MIN. VIA PAD SIZE:" at 11737.46,5975.8 h60
  text "30" at 12803.71,5975.8 h60
  text "MIL" at 12988.46,5975.8 h60
  text "0.05mm (2MIL)" at 12432.46,5845.9 h60
  text "MINIMUM ANNULAR RING" at 11408.23,5837.67 h60
  text "EXTERNAL" at 13140.46,5837.67 h60
  text "PER" at 11608.23,5727.55 h60
  text "IPC-D-275 CLASS 2 LEVEL C" at 11828.23,5727.54 h60
  text "MIL, HOLES" at 13316.46,5627.07 h60
  text "+/-" at 12924,5618.48 h60
  text "+/-" at 13778,5618.48 h60
  text "REGISTRATION TOLERANCES:" at 11408.23,5617.42 h60
  text "METAL" at 12608,5617.42 h60
  text "5" at 13184.2,5617.42 h60
  text "3" at 14017.2,5617.42 h60
  text "MIL" at 14133.46,5617.42 h60
  text "HOLE SIZE TOLERANCE (UNLESS OTHERWISE SPECIFIED):" at 11408.23,5519.1 h60
  text "+/-" at 13778,5516.23 h60
  text "3" at 14017.2,5515.17 h60
  text "MIL" at 14133.46,5515.17 h60
  text "MATERIAL:" at 11333.46,5377.52 h60
  text "FR-4 High Tg" at 12319.9,5249 h60
  text "X" at 12175.46,5241.01 h60
  text "FR-408" at 11754.46,5236.49 h60
  text "OTHER" at 13242.46,5236.49 h60
  text "62 MIL (1.6mm) +/-10%" at 12074.56,5093.46 h60
  text "X" at 11954.46,5091.01 h60
  text "THICKNESS:" at 11408.23,5085.24 h60
  text "OTHER" at 13359.46,5085.24 h60
  text "TOLERANCE:" at 11408.23,4946.92 h60
  text "X" at 12256.46,4946.92 h60
  text "ANSI IPC-6012 TYPE 3 CLASS 2" at 12434.48,4946.92 h60
  text "OTHER +/-" at 12434.46,4802.73 h60
  text "BOW & TWIST:" at 11408.23,4657.54 h60
  text "X" at 12256.46,4657.54 h60
  text "ANSI IPC-6012 TYPE 3 CLASS 2" at 12434.48,4657.54 h60
  text "OTHER +/-" at 12434.46,4510.85 h60
  text "DRILLING:" at 11333.46,4380.23 h60
  text "NC_DRILL FILES" at 13094.46,4275.04 h60
  text "REFERENCE:" at 11408.23,4271.1 h60
  text "X" at 12065.46,4271.01 h60
  text "AS SHOWN" at 12243.46,4271.1 h60
  text "X" at 12966.46,4271.1 h60
  text "OTHER" at 13392.46,4128.85 h60
  text "PTH COPPER THICKNESS:" at 11407.91,4125.32 h60
  text "X" at 12547.14,4125.32 h60
  text "20-30 um" at 12675.14,4125.32 h60
  text "BOARD FINISH:" at 11333.46,3977.73 h60
  text "SILKSCREEN:" at 11488.68,3867.6 h60
  text "X" at 12446.46,3867.6 h60
  text "TOP" at 12563.46,3867.6 h60
  text "X" at 12956.46,3867.6 h60
  text "BOTTOM" at 13074.46,3867.6 h60
  text "SILKSCREEN COLOR:" at 11488.68,3712.41 h60
  text "X" at 12445.46,3712.41 h60
  text "WHITE" at 12563.46,3712.41 h60
  text "OTHER" at 13074.46,3712.41 h60
  text "X" at 12576.46,3568.96 h60
  text "GREEN" at 12694.46,3568.96 h60
  text "OTHER" at 13312.46,3568.96 h60
  text "SOLDER RESIST COLOR:" at 11488.68,3562.1 h60
  text "X" at 12576.46,3414.71 h60
  text "MATTE" at 12694.46,3414.71 h60
  text "SEMI-GLOSS" at 13312,3414.07 h60
  text "IMMERSION GOLD (ENIG)" at 12394.46,3241.94 h60
  text "ENEPIG" at 13732,3234.72 h60
  text "SURFACE FINISH:" at 11333.46,3233.72 h60
  text "X" at 12216.46,3233.72 h60
  text "IMM. TIN/SILVER OR EQUIV" at 11663,3096.4 h60
  text "OTHER" at 13094.46,3092.47 h60
  text "ARRAY/PANEL:" at 11333.46,2937.09 h60
  text "CUT AND TRIM PER M1 BOARD OUTLINE" at 12394.46,2928.87 h60
  text "N.C. ROUTE" at 12394.46,2792.9 h60
  text "X" at 13082.46,2792.9 h60
  text "V. SCORE" at 13260.46,2792.9 h60
  text "CERTIFICATION:" at 11333.46,2663.77 h60
  text "MATERIALS AND WORKMANSHIP FOR ALL PCBS" at 12058.46,2663.77 h60
  text "TO MEET OR EXCEED THE REQUIREMENTS OF:" at 12058.46,2569.71 h60
  text "X" at 11695.97,2441.08 h60
  text "ANSI IPC-A-600F CLASS ->" at 11823.96,2441.08 h60
  text "X" at 13471.97,2441.08 h60
  text "2" at 13581.96,2441.08 h60
  text "1" at 13266.96,2439.58 h60
  text "3" at 13935.96,2439.58 h60
  text "X" at 12507.97,2293.39 h60
  text "RoHS" at 12635.96,2293.39 h60
  text "OTHER" at 13280.36,2293.39 h60
  text "PER ORDER" at 13677.42,2293.39 h60
  text "ALL BOARDS MUST MEET OR EXCEED UL94-V0 REQUIREMENTS." at 11361,2139.57 h60
  text "PCB MUST BEAR THE UL94V-0 UL REGISTERED MATERIAL ID NUMBER" at 11361,2023.5 h60
  text "ADDITIONAL REQUIREMENTS:" at 11333.46,1854.08 h60
  text "MICROSECTION:" at 11408.23,1746.95 h60
  text "YES" at 12313.96,1746.95 h60
  text "REQUIRED" at 13175.46,1602.62 h60
  text "BARE BOARD ELEC. TEST:" at 11408.23,1599.76 h60
  text "NONE" at 12713.96,1599.76 h60
  text "X" at 13057.46,1599.76 h60
  text "PER ORDER" at 13767.46,1599.76 h60
  text "XX MIL VIAS REQUIRE NON-CONDUCTIVE FILL AND PLANARIZE" at 11576.38,1394.82 h59
  text "XX MIL VIAS REQUIRE CONDUCTIVE FILL AND PLANARIZE" at 11584.38,1290.84 h60
  text "OUTER XX MIL TRACES REQUIRE 50 OHM SINGLE-ENDED IMPEDANCE" at 11583.39,1127.46 h58
  text "LAYER 2 & 3 (INNER LAYERS) XX MIL WIDE, XX MIL SPACE / TRACES REQUIRE 100 OHM DIFFERENTIAL IMPEDANCE" at 11575.39,891.74 h60
  text ".Layer_Name" at 577,-858.49 h60
M11 Gerber Information:
  lines w10: -292,-930.17 6308,-930.17 ; -292,-726.83 6310,-726.83 ; -292,-523.5 -292,-1133.5 3713,-1133.5 6310,-1133.5 6310,-523.5 -291.5,-523.5 -291.5,-1133.5 1284,-1133.5 ; 2173,-1133.5 2173,-523.5 ; 3440,-726.83 3440,-523.5 ; 4280,-726.83 4280,-523.5 ; 4902,-1140 4902,-937.17
  text "BOARD #:" at 2206,-606.3 h60
  text "ALL ARTWORK VIEWED FROM TOP SIDE" at -228.5,-655.67 h60
  text "REV:" at 3638,-655.67 h60
  text ".PCB_Rev" at 3929.5,-655.67 h60
  text "SVN REV:" at 4476,-655.67 h60
  text ".VersionControl_RevNumber" at 4982,-655.67 h60
  text ".PRJ_Number" at 2208.2,-705.7 h60
  text "LAYER NAME =" at -228.5,-858.49 h60
  text "TID #:" at 2248,-859 h60
  text ".TID" at 2793.5,-859 h60
  text "PLOT NAME =" at -228.5,-1064.34 h60
  text ".plot_File_Name" at 577,-1064.34 h60
  text "GENERATED    :" at 2250,-1064.34 h60
  text ".Print_Date" at 3119.5,-1064.34 h60
  text ".Print_Time" at 3848.5,-1064.34 h60
  text "TEXAS INSTRUMENTS" at 5113,-1064.34 h60
M12 Stackup:
  drawing of 295 lines, arcs and shapes, not listed
  text "Layer" at 6519.09,6958.5 h60
  text "Name" at 6929,6958.5 h60
  text "Material" at 7858.74,6958.5 h60
  text "Thickness" at 8718.51,6958.5 h60
  text "Constant" at 9368.35,6958.5 h60
  text "Board Layer Stack" at 9938.21,6958.5 h60
  text "Top Overlay" at 6929,6838.5 h60
  text "Top Solder" at 6929,6718.5 h60
  text "Solder Resist" at 7858.74,6718.5 h60
  text "0.40mil" at 8718.51,6718.5 h60
  text "3.5" at 9368.35,6718.5 h60
  text "1" at 6519.09,6598.5 h60
  text "Top Layer" at 6929,6598.5 h60
  text "Copper" at 7858.74,6598.5 h60
  text "2.80mil" at 8718.51,6598.5 h60
  text "Dielectric 2" at 6929,6478.5 h60
  text "FR-4" at 7858.74,6478.5 h60
  text "10.00mil" at 8718.51,6478.5 h60
  text "4.8" at 9368.35,6478.5 h60
  text "2" at 6519.09,6358.5 h60
  text "GND Layer" at 6929,6358.5 h60
  text "Copper" at 7858.74,6358.5 h60
  text "1.40mil" at 8718.51,6358.5 h60
  text "Dielectric 1" at 6929,6238.5 h60
  text "FR-4" at 7858.74,6238.5 h60
  text "30.00mil" at 8718.51,6238.5 h60
  text "4.2" at 9368.35,6238.5 h60
  text "3" at 6519.09,6118.5 h60
  text "Power Layer" at 6929,6118.5 h60
  text "Copper" at 7858.74,6118.5 h60
  text "1.40mil" at 8718.51,6118.5 h60
  text "Dielectric 3" at 6929,5998.5 h60
  text "FR-4" at 7858.74,5998.5 h60
  text "10.00mil" at 8718.51,5998.5 h60
  text "4.8" at 9368.35,5998.5 h60
  text "4" at 6519.09,5878.5 h60
  text "Bottom Layer" at 6929,5878.5 h60
  text "Copper" at 7858.74,5878.5 h60
  text "2.80mil" at 8718.51,5878.5 h60
  text "Solder Side" at 6929,5758.5 h60
  text "Solder Resist" at 7858.74,5758.5 h60
  text "0.40mil" at 8718.51,5758.5 h60
  text "3.5" at 9368.35,5758.5 h60
  text "Bottom Overlay" at 6929,5638.5 h60
  text ".Layer_Name" at 577,-858.49 h60
M13 Component Bodies Top:
  text ".Layer_Name" at 577,-858.49 h60
M14 Component Bodies Bottom:
  text ".Layer_Name" at 577,-858.49 h60
M15 Courtyards Top:
  text ".Layer_Name" at 577,-858.49 h60
M16 Courtyards Bottom:
  text ".Layer_Name" at 577,-858.49 h60
Drill Drawing:
  circle w10: c5363.72,3572.4 r16.58
  circle w10: c5363.72,3572.4 r27.63
  circle w10: c5363.72,2577.84 r27.63
  lines w10: 5336.09,2425.89 5336.09,2439.71 5349.9,2453.52 5336.09,2467.33 5336.09,2481.15 5349.9,2481.15 5363.72,2467.33 5377.53,2481.15 5391.34,2481.15 5391.34,2467.33 5377.53,2453.52 5391.34,2439.71 5391.34,2425.89 5377.53,2425.89 5363.72,2439.71 5349.9,2425.89 5336.09,2425.89 ; 5336.09,2688.35 5349.9,2688.35 5363.72,2674.53 5377.53,2688.35 5391.34,2688.35 5377.53,2702.16 5391.34,2715.97 5377.53,2715.97 5363.72,2729.79 5349.9,2715.97 5336.09,2715.97 5349.9,2702.16 5336.09,2688.35 ; 5336.09,2854.11 5391.34,2854.11 5363.72,2798.85 5336.09,2854.11 ; 5336.09,2936.99 5349.9,2936.99 5349.9,2923.17 5377.53,2923.17 5377.53,2936.99 5391.34,2936.99 5391.34,2964.61 5377.53,2964.61 5377.53,2978.43 5349.9,2978.43 5349.9,2964.61 5336.09,2964.61 5336.09,2936.99 ; 5336.09,3047.49 5363.72,3061.31 5391.34,3047.49 5377.53,3075.12 5391.34,3102.75 5363.72,3088.93 5336.09,3102.75 5349.9,3075.12 5336.09,3047.49 ; 5336.09,3185.63 5349.9,3185.63 5363.72,3171.81 5377.53,3185.63 5391.34,3185.63 5377.53,3199.44 5391.34,3213.25 5377.53,3213.25 5363.72,3227.07 5349.9,3213.25 5336.09,3213.25 5349.9,3199.44 5336.09,3185.63 ; 5336.09,3323.76 5363.72,3296.13 5391.34,3323.76 5363.72,3351.39 5336.09,3323.76 ; 5336.09,3420.45 5391.34,3420.45 5391.34,3475.71 5336.09,3475.71 5336.09,3420.45 ; 5336.09,3724.35 5391.34,3724.35 5363.72,3669.09 5336.09,3724.35 ; 5347.14,2693.87 5355.43,2693.87 5363.72,2685.59 5372.01,2693.87 5380.29,2693.87 5372.01,2702.16 5380.29,2710.45 5372.01,2710.45 5363.72,2718.74 5355.43,2710.45 5347.14,2710.45 5355.43,2702.16 5347.14,2693.87 ; 5347.14,3713.3 5380.29,3713.3 5363.72,3680.15 5347.14,3713.3
  lines w12: 5286,2388.6 8517.49,2388.6 ; 5286,3756.12 8517.49,3756.12 ; 5623.86,2264.28 5623.86,3880.44 ; 5955.86,2264.28 5955.86,3880.44 ; 6592.43,2264.28 6592.43,3880.44 ; 6851.57,2264.28 6851.57,3880.44 ; 7226.72,2264.28 7226.72,3880.44 ; 7951.05,2264.28 7951.05,3880.44 ; 5286,2264.28 8517.49,2264.28 8517.49,3880.44 5286,3880.44 5286,2264.28
  text "Symbol" at 5360.59,3793.41 h72
  text "Quantity" at 5661.16,3793.41 h72
  text "Finished Hole Size" at 5993.16,3793.41 h72
  text "Plated" at 6629.72,3793.41 h72
  text "Hole Type" at 6888.86,3793.41 h72
  text "Drill Layer Pair" at 7264.02,3793.41 h72
  text "Hole Tolerance" at 7988.35,3793.41 h72
  text "8" at 5661.16,3669.09 h60
  text "7.87mil (0.200mm)" at 5993.16,3669.09 h60
  text "PTH" at 6629.72,3669.09 h60
  text "Round" at 6888.86,3669.09 h60
  text "Top Layer - Bottom Layer" at 7264.02,3669.09 h60
  text "906" at 5661.16,3544.77 h60
  text "10.00mil (0.254mm)" at 5993.16,3544.77 h60
  text "PTH" at 6629.72,3544.77 h60
  text "Round" at 6888.86,3544.77 h60
  text "Top Layer - Bottom Layer" at 7264.02,3544.77 h60
  text "6" at 5661.16,3420.45 h60
  text "23.62mil (0.600mm)" at 5993.16,3420.45 h60
  text "PTH" at 6629.72,3420.45 h60
  text "Round" at 6888.86,3420.45 h60
  text "Top Layer - Bottom Layer" at 7264.02,3420.45 h60
  text "20" at 5661.16,3296.13 h60
  text "33.47mil (0.850mm)" at 5993.16,3296.13 h60
  text "PTH" at 6629.72,3296.13 h60
  text "Round" at 6888.86,3296.13 h60
  text "Top Layer - Bottom Layer" at 7264.02,3296.13 h60
  text "66" at 5661.16,3171.81 h60
  text "40.00mil (1.016mm)" at 5993.16,3171.81 h60
  text "PTH" at 6629.72,3171.81 h60
  text "Round" at 6888.86,3171.81 h60
  text "Top Layer - Bottom Layer" at 7264.02,3171.81 h60
  text "12" at 5661.16,3047.49 h60
  text "43.31mil (1.100mm)" at 5993.16,3047.49 h60
  text "PTH" at 6629.72,3047.49 h60
  text "Round" at 6888.86,3047.49 h60
  text "Top Layer - Bottom Layer" at 7264.02,3047.49 h60
  text "22" at 5661.16,2923.17 h60
  text "45.28mil (1.150mm)" at 5993.16,2923.17 h60
  text "PTH" at 6629.72,2923.17 h60
  text "Round" at 6888.86,2923.17 h60
  text "Top Layer - Bottom Layer" at 7264.02,2923.17 h60
  text "6" at 5661.16,2798.85 h60
  text "51.18mil (1.300mm)" at 5993.16,2798.85 h60
  text "PTH" at 6629.72,2798.85 h60
  text "Round" at 6888.86,2798.85 h60
  text "Top Layer - Bottom Layer" at 7264.02,2798.85 h60
  text "5" at 5661.16,2674.53 h60
  text "59.06mil (1.500mm)" at 5993.16,2674.53 h60
  text "PTH" at 6629.72,2674.53 h60
  text "Round" at 6888.86,2674.53 h60
  text "Top Layer - Bottom Layer" at 7264.02,2674.53 h60
  text "4" at 5661.16,2550.21 h60
  text "125.98mil (3.200mm)" at 5993.16,2550.21 h60
  text "PTH" at 6629.72,2550.21 h60
  text "Round" at 6888.86,2550.21 h60
  text "Top Layer - Bottom Layer" at 7264.02,2550.21 h60
  text "2" at 5661.16,2425.89 h60
  text "23.62mil (0.600mm)" at 5993.16,2425.89 h60
  text "PTH" at 6629.72,2425.89 h60
  text "Slot" at 6888.86,2425.89 h60
  text "Top Layer - Bottom Layer" at 7264.02,2425.89 h60
  text "1057 Total" at 5661.16,2301.57 h60
  text "Slot definitions :" at 5360.59,2214.55 h60
  text "Routed Path Length" at 5811.31,2214.55 h60
  text "= Calculated from tool start centre position to tool end centre position." at 6351.05,2214.55 h60
  text "Hole Length" at 5811.31,2164.82 h60
  text "= Routed Path Length + Tool Size = Slot length as defined in the PCB layout" at 6151.24,2164.82 h60
  text ".Layer_Name" at 577,-858.49 h60
M17 Embedded Cavity:
  text ".Layer_Name" at 577,-858.49 h60
M18 Embedded Assembly:
  text ".Layer_Name" at 577,-858.49 h60
M19 Embedded Keepout:
  text ".Layer_Name" at 577,-858.49 h60

## Dimensions
0,-400 to 1000,-400 on M2 Board Dimensions
0,0 to 0,4750 on M2 Board Dimensions
0,0 to 3650,0 on M2 Board Dimensions